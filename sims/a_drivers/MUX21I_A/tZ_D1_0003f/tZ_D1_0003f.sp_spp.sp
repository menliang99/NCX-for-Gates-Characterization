* Spectre Timing Acquisition
* Liberty NCX vD-2010.06-SP2
* Build(Aug 30 2010)
* Filename: tZ_D1_0003f.sp

* combinational_fall Fall
* Driver Waveform Type: active_driver
* PWL Active Driver
* Pin Name: Z
* Related Input Pin: D1
* Input Waveform: Rise
* input_threshold_pct_rise: 50.00
* output_threshold_pct_rise: 50.00
* input_threshold_pct_fall: 50.00
* output_threshold_pct_fall: 50.00
* slew_lower_threshold_pct_rise: 10.00
* slew_upper_threshold_pct_rise: 90.00
* slew_lower_threshold_pct_fall: 10.00
* slew_upper_threshold_pct_fall: 90.00
* capacitance_lower_threshold_pct_rise: 0.50
* capacitance_upper_threshold_pct_rise: 90.00
* capacitance_lower_threshold_pct_fall: 10.00
* capacitance_upper_threshold_pct_fall: 99.50
* slew_derate_from_library: 1.00
* Clock Width(ps): 3000.000000

* Pin Signal Voltage Level:
* Pin D1:		 H=1.200000	 L=0.000000
* Pin SD:		 H=1.200000	 L=0.000000
* Pin Z:		 H=1.200000	 L=0.000000

* Lib Slew Index(ps): 50.000000 70.000000 90.000000 100.000000 130.000000 150.000000 170.000000 190.000000 210.000000 250.000000 300.000000 500.000000 700.000000 900.000000
* Input Transition Time(ps): 50.000000 70.000000 90.000000 100.000000 130.000000 150.000000 170.000000 190.000000 210.000000 250.000000 300.000000 500.000000 700.000000 900.000000
* Lib Load Index(ff): 3.800000 4.100000 4.400000 4.700000 5.000000 5.300000 5.600000 5.900000

* Set output format:
 simulator lang = spectre

* TEMPERATURE ==========================
temperature options temp= 2.500000e+01

* MODELS ===============================
*include "/home/mliang/HeteroTape2/NCXforBool/design_modified.scs"

* CELL SUBCKT ==========================
include "/home/mliang/HeteroTape2/NCXforBool/netlists/MUX21I_A.scs"

* OPTIONS ==============================
* NCX Default Options:
settings options rawfmt=psfascii

 simulator lang = spice
.OPTIONS NUMDGT=10 MEASDGT=10

 simulator lang = spectre
* End of NCX Default Options.

* Lib Level Options:
* No Lib Level Options Here
* Cell Level Options:
* No Cell Level Options Here
* Pin Level Options:
* No Pin Level Options Here
* Arc Level Options:
* No Arc Level Options Here

* VOLTAGE SOURCES ======================
global gnd
Vn_GND n_GND gnd vsource type=dc dc=0.000000e+00
Vn_VDD n_VDD gnd vsource type=dc dc=1.200000e+00
V0_gnd 0 gnd vsource type=dc dc=0.0

* ACQUISITION CIRCUIT ==================
X_MUX21I_A n_D0 n_D1 n_SD n_GND n_VDD n_Z MUX21I_A
Vn_D1 n_D1 n_D12 vsource type=dc dc=0
Vn_SD n_SD n_SD2 vsource type=dc dc=0
Vn_Z n_Z n_Z1 vsource type=dc dc=0
CLD_Z n_Z1 gnd capacitor c=load_cap
parameters sidecap = 5.0000000000e-15

* PROBE ================================
 save n_Z Vn_Z n_D1 Vn_D1 n_SD Vn_SD Vn_GND Vn_VDD

* STIMULI ==============================
* InPin D1 PWL length=31
* InPin SD PWL length=6
* Sensitization Template Name: MUX21I_A_wave_0_4
* SensInputs= D1: 	001
* SensInputs= SD: 	111
* SensOuputs= Z: 	10

* ncxtd: Measurement Starting time
* adrv_cap: Active Driver Output Load
* iptr: Input Transition Time
* load_cap: Relative Output Pin Load
parameters index=0 ncxtd=1 adrv_cap=0 iptr=0 load_cap=0
parameters  t_D10=0.00 v_D10=0 t_D11=0.01 v_D11=0 t_D12=0.02 v_D12=0 t_D13=0.03 v_D13=0 t_D14=0.04 v_D14=0 t_D15=0.05 v_D15=0 t_D16=0.06 v_D16=0 t_D17=0.07 v_D17=0 t_D18=0.08 v_D18=0 t_D19=0.09 v_D19=0 t_D110=0.10 v_D110=0 t_D111=0.11 v_D111=0 t_D112=0.12 v_D112=0 t_D113=0.13 v_D113=0 t_D114=0.14 v_D114=0 t_D115=0.15 v_D115=0 t_D116=0.16 v_D116=0 t_D117=0.17 v_D117=0 t_D118=0.18 v_D118=0 t_D119=0.19 v_D119=0 t_D120=0.20 v_D120=0 t_D121=0.21 v_D121=0 t_D122=0.22 v_D122=0 t_D123=0.23 v_D123=0 t_D124=0.24 v_D124=0 t_D125=0.25 v_D125=0 t_D126=0.26 v_D126=0 t_D127=0.27 v_D127=0 t_D128=0.28 v_D128=0 t_D129=0.29 v_D129=0 t_D130=0.30 v_D130=0
parameters  t_SD0=0.00 v_SD0=0 t_SD1=0.01 v_SD1=0 t_SD2=0.02 v_SD2=0 t_SD3=0.03 v_SD3=0 t_SD4=0.04 v_SD4=0 t_SD5=0.05 v_SD5=0
stimdata paramset {
index ncxtd adrv_cap iptr load_cap \
 t_D10 v_D10 t_D11 v_D11 t_D12 v_D12 t_D13 v_D13 t_D14 v_D14 t_D15 v_D15 t_D16 v_D16 t_D17 v_D17 t_D18 v_D18 t_D19 v_D19 \
 t_D110 v_D110 t_D111 v_D111 t_D112 v_D112 t_D113 v_D113 t_D114 v_D114 t_D115 v_D115 t_D116 v_D116 t_D117 v_D117 t_D118 v_D118 t_D119 v_D119 \
 t_D120 v_D120 t_D121 v_D121 t_D122 v_D122 t_D123 v_D123 t_D124 v_D124 t_D125 v_D125 t_D126 v_D126 t_D127 v_D127 t_D128 v_D128 t_D129 v_D129 \
 t_D130 v_D130 \
 t_SD0 v_SD0 t_SD1 v_SD1 t_SD2 v_SD2 t_SD3 v_SD3 t_SD4 v_SD4 t_SD5 v_SD5 \

   0 6.0200000000e-09 5.0000000000e-12 5.0000000000e-11 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997954e-09 0.0000000000e+00 \
 6.0399885553e-09 2.4000000000e-02 6.0599773151e-09 4.8000000000e-02 6.0799660750e-09 7.2000000000e-02 6.0999548349e-09 9.6000000000e-02 6.1188887143e-09 1.2000000000e-01 \
 6.1218589981e-09 1.8000000000e-01 6.1245112261e-09 2.4000000000e-01 6.1270210695e-09 3.0000000000e-01 6.1294860186e-09 3.6000000000e-01 6.1319041496e-09 4.2000000000e-01 \
 6.1343484800e-09 4.8000000000e-01 6.1368040547e-09 5.4000000000e-01 6.1393477232e-09 6.0000000000e-01 6.1419131878e-09 6.6000000000e-01 6.1446913499e-09 7.2000000000e-01 \
 6.1474996138e-09 7.8000000000e-01 6.1505186457e-09 8.4000000000e-01 6.1539160422e-09 9.0000000000e-01 6.1577661277e-09 9.6000000000e-01 6.1627126416e-09 1.0200000000e+00 \
 6.1688860411e-09 1.0800000000e+00 6.1726442898e-09 1.1040000000e+00 6.1771751999e-09 1.1280000000e+00 6.1852685662e-09 1.1520000000e+00 6.1933619324e-09 1.1760000000e+00 \
 1.0501459328e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
   1 6.0200000000e-09 5.0000000000e-12 5.0000000000e-11 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997954e-09 0.0000000000e+00 \
 6.0399885553e-09 2.4000000000e-02 6.0599773151e-09 4.8000000000e-02 6.0799660750e-09 7.2000000000e-02 6.0999548349e-09 9.6000000000e-02 6.1188887143e-09 1.2000000000e-01 \
 6.1218589981e-09 1.8000000000e-01 6.1245112261e-09 2.4000000000e-01 6.1270210695e-09 3.0000000000e-01 6.1294860186e-09 3.6000000000e-01 6.1319041496e-09 4.2000000000e-01 \
 6.1343484800e-09 4.8000000000e-01 6.1368040547e-09 5.4000000000e-01 6.1393477232e-09 6.0000000000e-01 6.1419131878e-09 6.6000000000e-01 6.1446913499e-09 7.2000000000e-01 \
 6.1474996138e-09 7.8000000000e-01 6.1505186457e-09 8.4000000000e-01 6.1539160422e-09 9.0000000000e-01 6.1577661277e-09 9.6000000000e-01 6.1627126416e-09 1.0200000000e+00 \
 6.1688860411e-09 1.0800000000e+00 6.1726442898e-09 1.1040000000e+00 6.1771751999e-09 1.1280000000e+00 6.1852685662e-09 1.1520000000e+00 6.1933619324e-09 1.1760000000e+00 \
 1.0501459328e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
   2 6.0200000000e-09 5.0000000000e-12 5.0000000000e-11 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997954e-09 0.0000000000e+00 \
 6.0399885553e-09 2.4000000000e-02 6.0599773151e-09 4.8000000000e-02 6.0799660750e-09 7.2000000000e-02 6.0999548349e-09 9.6000000000e-02 6.1188887143e-09 1.2000000000e-01 \
 6.1218589981e-09 1.8000000000e-01 6.1245112261e-09 2.4000000000e-01 6.1270210695e-09 3.0000000000e-01 6.1294860186e-09 3.6000000000e-01 6.1319041496e-09 4.2000000000e-01 \
 6.1343484800e-09 4.8000000000e-01 6.1368040547e-09 5.4000000000e-01 6.1393477232e-09 6.0000000000e-01 6.1419131878e-09 6.6000000000e-01 6.1446913499e-09 7.2000000000e-01 \
 6.1474996138e-09 7.8000000000e-01 6.1505186457e-09 8.4000000000e-01 6.1539160422e-09 9.0000000000e-01 6.1577661277e-09 9.6000000000e-01 6.1627126416e-09 1.0200000000e+00 \
 6.1688860411e-09 1.0800000000e+00 6.1726442898e-09 1.1040000000e+00 6.1771751999e-09 1.1280000000e+00 6.1852685662e-09 1.1520000000e+00 6.1933619324e-09 1.1760000000e+00 \
 1.0501459328e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
   3 6.0200000000e-09 5.0000000000e-12 5.0000000000e-11 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997954e-09 0.0000000000e+00 \
 6.0399885553e-09 2.4000000000e-02 6.0599773151e-09 4.8000000000e-02 6.0799660750e-09 7.2000000000e-02 6.0999548349e-09 9.6000000000e-02 6.1188887143e-09 1.2000000000e-01 \
 6.1218589981e-09 1.8000000000e-01 6.1245112261e-09 2.4000000000e-01 6.1270210695e-09 3.0000000000e-01 6.1294860186e-09 3.6000000000e-01 6.1319041496e-09 4.2000000000e-01 \
 6.1343484800e-09 4.8000000000e-01 6.1368040547e-09 5.4000000000e-01 6.1393477232e-09 6.0000000000e-01 6.1419131878e-09 6.6000000000e-01 6.1446913499e-09 7.2000000000e-01 \
 6.1474996138e-09 7.8000000000e-01 6.1505186457e-09 8.4000000000e-01 6.1539160422e-09 9.0000000000e-01 6.1577661277e-09 9.6000000000e-01 6.1627126416e-09 1.0200000000e+00 \
 6.1688860411e-09 1.0800000000e+00 6.1726442898e-09 1.1040000000e+00 6.1771751999e-09 1.1280000000e+00 6.1852685662e-09 1.1520000000e+00 6.1933619324e-09 1.1760000000e+00 \
 1.0501459328e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
   4 6.0200000000e-09 5.0000000000e-12 5.0000000000e-11 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997954e-09 0.0000000000e+00 \
 6.0399885553e-09 2.4000000000e-02 6.0599773151e-09 4.8000000000e-02 6.0799660750e-09 7.2000000000e-02 6.0999548349e-09 9.6000000000e-02 6.1188887143e-09 1.2000000000e-01 \
 6.1218589981e-09 1.8000000000e-01 6.1245112261e-09 2.4000000000e-01 6.1270210695e-09 3.0000000000e-01 6.1294860186e-09 3.6000000000e-01 6.1319041496e-09 4.2000000000e-01 \
 6.1343484800e-09 4.8000000000e-01 6.1368040547e-09 5.4000000000e-01 6.1393477232e-09 6.0000000000e-01 6.1419131878e-09 6.6000000000e-01 6.1446913499e-09 7.2000000000e-01 \
 6.1474996138e-09 7.8000000000e-01 6.1505186457e-09 8.4000000000e-01 6.1539160422e-09 9.0000000000e-01 6.1577661277e-09 9.6000000000e-01 6.1627126416e-09 1.0200000000e+00 \
 6.1688860411e-09 1.0800000000e+00 6.1726442898e-09 1.1040000000e+00 6.1771751999e-09 1.1280000000e+00 6.1852685662e-09 1.1520000000e+00 6.1933619324e-09 1.1760000000e+00 \
 1.0501459328e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
   5 6.0200000000e-09 5.0000000000e-12 5.0000000000e-11 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997954e-09 0.0000000000e+00 \
 6.0399885553e-09 2.4000000000e-02 6.0599773151e-09 4.8000000000e-02 6.0799660750e-09 7.2000000000e-02 6.0999548349e-09 9.6000000000e-02 6.1188887143e-09 1.2000000000e-01 \
 6.1218589981e-09 1.8000000000e-01 6.1245112261e-09 2.4000000000e-01 6.1270210695e-09 3.0000000000e-01 6.1294860186e-09 3.6000000000e-01 6.1319041496e-09 4.2000000000e-01 \
 6.1343484800e-09 4.8000000000e-01 6.1368040547e-09 5.4000000000e-01 6.1393477232e-09 6.0000000000e-01 6.1419131878e-09 6.6000000000e-01 6.1446913499e-09 7.2000000000e-01 \
 6.1474996138e-09 7.8000000000e-01 6.1505186457e-09 8.4000000000e-01 6.1539160422e-09 9.0000000000e-01 6.1577661277e-09 9.6000000000e-01 6.1627126416e-09 1.0200000000e+00 \
 6.1688860411e-09 1.0800000000e+00 6.1726442898e-09 1.1040000000e+00 6.1771751999e-09 1.1280000000e+00 6.1852685662e-09 1.1520000000e+00 6.1933619324e-09 1.1760000000e+00 \
 1.0501459328e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
   6 6.0200000000e-09 5.0000000000e-12 5.0000000000e-11 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997954e-09 0.0000000000e+00 \
 6.0399885553e-09 2.4000000000e-02 6.0599773151e-09 4.8000000000e-02 6.0799660750e-09 7.2000000000e-02 6.0999548349e-09 9.6000000000e-02 6.1188887143e-09 1.2000000000e-01 \
 6.1218589981e-09 1.8000000000e-01 6.1245112261e-09 2.4000000000e-01 6.1270210695e-09 3.0000000000e-01 6.1294860186e-09 3.6000000000e-01 6.1319041496e-09 4.2000000000e-01 \
 6.1343484800e-09 4.8000000000e-01 6.1368040547e-09 5.4000000000e-01 6.1393477232e-09 6.0000000000e-01 6.1419131878e-09 6.6000000000e-01 6.1446913499e-09 7.2000000000e-01 \
 6.1474996138e-09 7.8000000000e-01 6.1505186457e-09 8.4000000000e-01 6.1539160422e-09 9.0000000000e-01 6.1577661277e-09 9.6000000000e-01 6.1627126416e-09 1.0200000000e+00 \
 6.1688860411e-09 1.0800000000e+00 6.1726442898e-09 1.1040000000e+00 6.1771751999e-09 1.1280000000e+00 6.1852685662e-09 1.1520000000e+00 6.1933619324e-09 1.1760000000e+00 \
 1.0501459328e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
   7 6.0200000000e-09 5.0000000000e-12 5.0000000000e-11 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997954e-09 0.0000000000e+00 \
 6.0399885553e-09 2.4000000000e-02 6.0599773151e-09 4.8000000000e-02 6.0799660750e-09 7.2000000000e-02 6.0999548349e-09 9.6000000000e-02 6.1188887143e-09 1.2000000000e-01 \
 6.1218589981e-09 1.8000000000e-01 6.1245112261e-09 2.4000000000e-01 6.1270210695e-09 3.0000000000e-01 6.1294860186e-09 3.6000000000e-01 6.1319041496e-09 4.2000000000e-01 \
 6.1343484800e-09 4.8000000000e-01 6.1368040547e-09 5.4000000000e-01 6.1393477232e-09 6.0000000000e-01 6.1419131878e-09 6.6000000000e-01 6.1446913499e-09 7.2000000000e-01 \
 6.1474996138e-09 7.8000000000e-01 6.1505186457e-09 8.4000000000e-01 6.1539160422e-09 9.0000000000e-01 6.1577661277e-09 9.6000000000e-01 6.1627126416e-09 1.0200000000e+00 \
 6.1688860411e-09 1.0800000000e+00 6.1726442898e-09 1.1040000000e+00 6.1771751999e-09 1.1280000000e+00 6.1852685662e-09 1.1520000000e+00 6.1933619324e-09 1.1760000000e+00 \
 1.0501459328e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
   8 6.0200000000e-09 5.0000000000e-12 7.0000000000e-11 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997434e-09 0.0000000000e+00 \
 6.0450672908e-09 2.4000000000e-02 6.0701348381e-09 4.8000000000e-02 6.0952023854e-09 7.2000000000e-02 6.1200897361e-09 9.6000000000e-02 6.1216402340e-09 1.2000000000e-01 \
 6.1254717006e-09 1.8000000000e-01 6.1289149901e-09 2.4000000000e-01 6.1322699247e-09 3.0000000000e-01 6.1356129740e-09 3.6000000000e-01 6.1389790130e-09 4.2000000000e-01 \
 6.1424118471e-09 4.8000000000e-01 6.1459450497e-09 5.4000000000e-01 6.1495182417e-09 6.0000000000e-01 6.1532559767e-09 6.6000000000e-01 6.1571092565e-09 7.2000000000e-01 \
 6.1612179740e-09 7.8000000000e-01 6.1655374542e-09 8.4000000000e-01 6.1705539304e-09 9.0000000000e-01 6.1761173011e-09 9.6000000000e-01 6.1831122181e-09 1.0200000000e+00 \
 6.1921155201e-09 1.0800000000e+00 6.1971747854e-09 1.1040000000e+00 6.2045234842e-09 1.1280000000e+00 6.2118721831e-09 1.1520000000e+00 6.2356667261e-09 1.1760000000e+00 \
 1.0510868093e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
   9 6.0200000000e-09 5.0000000000e-12 7.0000000000e-11 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997434e-09 0.0000000000e+00 \
 6.0450672908e-09 2.4000000000e-02 6.0701348381e-09 4.8000000000e-02 6.0952023854e-09 7.2000000000e-02 6.1200897361e-09 9.6000000000e-02 6.1216402340e-09 1.2000000000e-01 \
 6.1254717006e-09 1.8000000000e-01 6.1289149901e-09 2.4000000000e-01 6.1322699247e-09 3.0000000000e-01 6.1356129740e-09 3.6000000000e-01 6.1389790130e-09 4.2000000000e-01 \
 6.1424118471e-09 4.8000000000e-01 6.1459450497e-09 5.4000000000e-01 6.1495182417e-09 6.0000000000e-01 6.1532559767e-09 6.6000000000e-01 6.1571092565e-09 7.2000000000e-01 \
 6.1612179740e-09 7.8000000000e-01 6.1655374542e-09 8.4000000000e-01 6.1705539304e-09 9.0000000000e-01 6.1761173011e-09 9.6000000000e-01 6.1831122181e-09 1.0200000000e+00 \
 6.1921155201e-09 1.0800000000e+00 6.1971747854e-09 1.1040000000e+00 6.2045234842e-09 1.1280000000e+00 6.2118721831e-09 1.1520000000e+00 6.2356667261e-09 1.1760000000e+00 \
 1.0510868093e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  10 6.0200000000e-09 5.0000000000e-12 7.0000000000e-11 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997434e-09 0.0000000000e+00 \
 6.0450672908e-09 2.4000000000e-02 6.0701348381e-09 4.8000000000e-02 6.0952023854e-09 7.2000000000e-02 6.1200897361e-09 9.6000000000e-02 6.1216402340e-09 1.2000000000e-01 \
 6.1254717006e-09 1.8000000000e-01 6.1289149901e-09 2.4000000000e-01 6.1322699247e-09 3.0000000000e-01 6.1356129740e-09 3.6000000000e-01 6.1389790130e-09 4.2000000000e-01 \
 6.1424118471e-09 4.8000000000e-01 6.1459450497e-09 5.4000000000e-01 6.1495182417e-09 6.0000000000e-01 6.1532559767e-09 6.6000000000e-01 6.1571092565e-09 7.2000000000e-01 \
 6.1612179740e-09 7.8000000000e-01 6.1655374542e-09 8.4000000000e-01 6.1705539304e-09 9.0000000000e-01 6.1761173011e-09 9.6000000000e-01 6.1831122181e-09 1.0200000000e+00 \
 6.1921155201e-09 1.0800000000e+00 6.1971747854e-09 1.1040000000e+00 6.2045234842e-09 1.1280000000e+00 6.2118721831e-09 1.1520000000e+00 6.2356667261e-09 1.1760000000e+00 \
 1.0510868093e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  11 6.0200000000e-09 5.0000000000e-12 7.0000000000e-11 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997434e-09 0.0000000000e+00 \
 6.0450672908e-09 2.4000000000e-02 6.0701348381e-09 4.8000000000e-02 6.0952023854e-09 7.2000000000e-02 6.1200897361e-09 9.6000000000e-02 6.1216402340e-09 1.2000000000e-01 \
 6.1254717006e-09 1.8000000000e-01 6.1289149901e-09 2.4000000000e-01 6.1322699247e-09 3.0000000000e-01 6.1356129740e-09 3.6000000000e-01 6.1389790130e-09 4.2000000000e-01 \
 6.1424118471e-09 4.8000000000e-01 6.1459450497e-09 5.4000000000e-01 6.1495182417e-09 6.0000000000e-01 6.1532559767e-09 6.6000000000e-01 6.1571092565e-09 7.2000000000e-01 \
 6.1612179740e-09 7.8000000000e-01 6.1655374542e-09 8.4000000000e-01 6.1705539304e-09 9.0000000000e-01 6.1761173011e-09 9.6000000000e-01 6.1831122181e-09 1.0200000000e+00 \
 6.1921155201e-09 1.0800000000e+00 6.1971747854e-09 1.1040000000e+00 6.2045234842e-09 1.1280000000e+00 6.2118721831e-09 1.1520000000e+00 6.2356667261e-09 1.1760000000e+00 \
 1.0510868093e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  12 6.0200000000e-09 5.0000000000e-12 7.0000000000e-11 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997434e-09 0.0000000000e+00 \
 6.0450672908e-09 2.4000000000e-02 6.0701348381e-09 4.8000000000e-02 6.0952023854e-09 7.2000000000e-02 6.1200897361e-09 9.6000000000e-02 6.1216402340e-09 1.2000000000e-01 \
 6.1254717006e-09 1.8000000000e-01 6.1289149901e-09 2.4000000000e-01 6.1322699247e-09 3.0000000000e-01 6.1356129740e-09 3.6000000000e-01 6.1389790130e-09 4.2000000000e-01 \
 6.1424118471e-09 4.8000000000e-01 6.1459450497e-09 5.4000000000e-01 6.1495182417e-09 6.0000000000e-01 6.1532559767e-09 6.6000000000e-01 6.1571092565e-09 7.2000000000e-01 \
 6.1612179740e-09 7.8000000000e-01 6.1655374542e-09 8.4000000000e-01 6.1705539304e-09 9.0000000000e-01 6.1761173011e-09 9.6000000000e-01 6.1831122181e-09 1.0200000000e+00 \
 6.1921155201e-09 1.0800000000e+00 6.1971747854e-09 1.1040000000e+00 6.2045234842e-09 1.1280000000e+00 6.2118721831e-09 1.1520000000e+00 6.2356667261e-09 1.1760000000e+00 \
 1.0510868093e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  13 6.0200000000e-09 5.0000000000e-12 7.0000000000e-11 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997434e-09 0.0000000000e+00 \
 6.0450672908e-09 2.4000000000e-02 6.0701348381e-09 4.8000000000e-02 6.0952023854e-09 7.2000000000e-02 6.1200897361e-09 9.6000000000e-02 6.1216402340e-09 1.2000000000e-01 \
 6.1254717006e-09 1.8000000000e-01 6.1289149901e-09 2.4000000000e-01 6.1322699247e-09 3.0000000000e-01 6.1356129740e-09 3.6000000000e-01 6.1389790130e-09 4.2000000000e-01 \
 6.1424118471e-09 4.8000000000e-01 6.1459450497e-09 5.4000000000e-01 6.1495182417e-09 6.0000000000e-01 6.1532559767e-09 6.6000000000e-01 6.1571092565e-09 7.2000000000e-01 \
 6.1612179740e-09 7.8000000000e-01 6.1655374542e-09 8.4000000000e-01 6.1705539304e-09 9.0000000000e-01 6.1761173011e-09 9.6000000000e-01 6.1831122181e-09 1.0200000000e+00 \
 6.1921155201e-09 1.0800000000e+00 6.1971747854e-09 1.1040000000e+00 6.2045234842e-09 1.1280000000e+00 6.2118721831e-09 1.1520000000e+00 6.2356667261e-09 1.1760000000e+00 \
 1.0510868093e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  14 6.0200000000e-09 5.0000000000e-12 7.0000000000e-11 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997434e-09 0.0000000000e+00 \
 6.0450672908e-09 2.4000000000e-02 6.0701348381e-09 4.8000000000e-02 6.0952023854e-09 7.2000000000e-02 6.1200897361e-09 9.6000000000e-02 6.1216402340e-09 1.2000000000e-01 \
 6.1254717006e-09 1.8000000000e-01 6.1289149901e-09 2.4000000000e-01 6.1322699247e-09 3.0000000000e-01 6.1356129740e-09 3.6000000000e-01 6.1389790130e-09 4.2000000000e-01 \
 6.1424118471e-09 4.8000000000e-01 6.1459450497e-09 5.4000000000e-01 6.1495182417e-09 6.0000000000e-01 6.1532559767e-09 6.6000000000e-01 6.1571092565e-09 7.2000000000e-01 \
 6.1612179740e-09 7.8000000000e-01 6.1655374542e-09 8.4000000000e-01 6.1705539304e-09 9.0000000000e-01 6.1761173011e-09 9.6000000000e-01 6.1831122181e-09 1.0200000000e+00 \
 6.1921155201e-09 1.0800000000e+00 6.1971747854e-09 1.1040000000e+00 6.2045234842e-09 1.1280000000e+00 6.2118721831e-09 1.1520000000e+00 6.2356667261e-09 1.1760000000e+00 \
 1.0510868093e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  15 6.0200000000e-09 5.0000000000e-12 7.0000000000e-11 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199997434e-09 0.0000000000e+00 \
 6.0450672908e-09 2.4000000000e-02 6.0701348381e-09 4.8000000000e-02 6.0952023854e-09 7.2000000000e-02 6.1200897361e-09 9.6000000000e-02 6.1216402340e-09 1.2000000000e-01 \
 6.1254717006e-09 1.8000000000e-01 6.1289149901e-09 2.4000000000e-01 6.1322699247e-09 3.0000000000e-01 6.1356129740e-09 3.6000000000e-01 6.1389790130e-09 4.2000000000e-01 \
 6.1424118471e-09 4.8000000000e-01 6.1459450497e-09 5.4000000000e-01 6.1495182417e-09 6.0000000000e-01 6.1532559767e-09 6.6000000000e-01 6.1571092565e-09 7.2000000000e-01 \
 6.1612179740e-09 7.8000000000e-01 6.1655374542e-09 8.4000000000e-01 6.1705539304e-09 9.0000000000e-01 6.1761173011e-09 9.6000000000e-01 6.1831122181e-09 1.0200000000e+00 \
 6.1921155201e-09 1.0800000000e+00 6.1971747854e-09 1.1040000000e+00 6.2045234842e-09 1.1280000000e+00 6.2118721831e-09 1.1520000000e+00 6.2356667261e-09 1.1760000000e+00 \
 1.0510868093e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  16 6.0200000000e-09 5.0000000000e-12 9.0000000000e-11 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995502e-09 0.0000000000e+00 \
 6.0639515131e-09 2.4000000000e-02 6.1079034760e-09 4.8000000000e-02 6.1198796018e-09 7.2000000000e-02 6.1220887532e-09 9.6000000000e-02 6.1239274768e-09 1.2000000000e-01 \
 6.1285090920e-09 1.8000000000e-01 6.1327688324e-09 2.4000000000e-01 6.1369935194e-09 3.0000000000e-01 6.1412662297e-09 3.6000000000e-01 6.1456284987e-09 4.2000000000e-01 \
 6.1500573281e-09 4.8000000000e-01 6.1546052927e-09 5.4000000000e-01 6.1592498315e-09 6.0000000000e-01 6.1640922657e-09 6.6000000000e-01 6.1691777122e-09 7.2000000000e-01 \
 6.1745121473e-09 7.8000000000e-01 6.1802336794e-09 8.4000000000e-01 6.1868883533e-09 9.0000000000e-01 6.1935430273e-09 9.6000000000e-01 6.2028143955e-09 1.0200000000e+00 \
 6.2144573584e-09 1.0800000000e+00 6.2211479701e-09 1.1040000000e+00 6.2302871809e-09 1.1280000000e+00 6.2394263918e-09 1.1520000000e+00 6.2712608219e-09 1.1760000000e+00 \
 1.0507129661e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  17 6.0200000000e-09 5.0000000000e-12 9.0000000000e-11 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995502e-09 0.0000000000e+00 \
 6.0639515131e-09 2.4000000000e-02 6.1079034760e-09 4.8000000000e-02 6.1198796018e-09 7.2000000000e-02 6.1220887532e-09 9.6000000000e-02 6.1239274768e-09 1.2000000000e-01 \
 6.1285090920e-09 1.8000000000e-01 6.1327688324e-09 2.4000000000e-01 6.1369935194e-09 3.0000000000e-01 6.1412662297e-09 3.6000000000e-01 6.1456284987e-09 4.2000000000e-01 \
 6.1500573281e-09 4.8000000000e-01 6.1546052927e-09 5.4000000000e-01 6.1592498315e-09 6.0000000000e-01 6.1640922657e-09 6.6000000000e-01 6.1691777122e-09 7.2000000000e-01 \
 6.1745121473e-09 7.8000000000e-01 6.1802336794e-09 8.4000000000e-01 6.1868883533e-09 9.0000000000e-01 6.1935430273e-09 9.6000000000e-01 6.2028143955e-09 1.0200000000e+00 \
 6.2144573584e-09 1.0800000000e+00 6.2211479701e-09 1.1040000000e+00 6.2302871809e-09 1.1280000000e+00 6.2394263918e-09 1.1520000000e+00 6.2712608219e-09 1.1760000000e+00 \
 1.0507129661e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  18 6.0200000000e-09 5.0000000000e-12 9.0000000000e-11 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995502e-09 0.0000000000e+00 \
 6.0639515131e-09 2.4000000000e-02 6.1079034760e-09 4.8000000000e-02 6.1198796018e-09 7.2000000000e-02 6.1220887532e-09 9.6000000000e-02 6.1239274768e-09 1.2000000000e-01 \
 6.1285090920e-09 1.8000000000e-01 6.1327688324e-09 2.4000000000e-01 6.1369935194e-09 3.0000000000e-01 6.1412662297e-09 3.6000000000e-01 6.1456284987e-09 4.2000000000e-01 \
 6.1500573281e-09 4.8000000000e-01 6.1546052927e-09 5.4000000000e-01 6.1592498315e-09 6.0000000000e-01 6.1640922657e-09 6.6000000000e-01 6.1691777122e-09 7.2000000000e-01 \
 6.1745121473e-09 7.8000000000e-01 6.1802336794e-09 8.4000000000e-01 6.1868883533e-09 9.0000000000e-01 6.1935430273e-09 9.6000000000e-01 6.2028143955e-09 1.0200000000e+00 \
 6.2144573584e-09 1.0800000000e+00 6.2211479701e-09 1.1040000000e+00 6.2302871809e-09 1.1280000000e+00 6.2394263918e-09 1.1520000000e+00 6.2712608219e-09 1.1760000000e+00 \
 1.0507129661e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  19 6.0200000000e-09 5.0000000000e-12 9.0000000000e-11 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995502e-09 0.0000000000e+00 \
 6.0639515131e-09 2.4000000000e-02 6.1079034760e-09 4.8000000000e-02 6.1198796018e-09 7.2000000000e-02 6.1220887532e-09 9.6000000000e-02 6.1239274768e-09 1.2000000000e-01 \
 6.1285090920e-09 1.8000000000e-01 6.1327688324e-09 2.4000000000e-01 6.1369935194e-09 3.0000000000e-01 6.1412662297e-09 3.6000000000e-01 6.1456284987e-09 4.2000000000e-01 \
 6.1500573281e-09 4.8000000000e-01 6.1546052927e-09 5.4000000000e-01 6.1592498315e-09 6.0000000000e-01 6.1640922657e-09 6.6000000000e-01 6.1691777122e-09 7.2000000000e-01 \
 6.1745121473e-09 7.8000000000e-01 6.1802336794e-09 8.4000000000e-01 6.1868883533e-09 9.0000000000e-01 6.1935430273e-09 9.6000000000e-01 6.2028143955e-09 1.0200000000e+00 \
 6.2144573584e-09 1.0800000000e+00 6.2211479701e-09 1.1040000000e+00 6.2302871809e-09 1.1280000000e+00 6.2394263918e-09 1.1520000000e+00 6.2712608219e-09 1.1760000000e+00 \
 1.0507129661e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  20 6.0200000000e-09 5.0000000000e-12 9.0000000000e-11 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995502e-09 0.0000000000e+00 \
 6.0639515131e-09 2.4000000000e-02 6.1079034760e-09 4.8000000000e-02 6.1198796018e-09 7.2000000000e-02 6.1220887532e-09 9.6000000000e-02 6.1239274768e-09 1.2000000000e-01 \
 6.1285090920e-09 1.8000000000e-01 6.1327688324e-09 2.4000000000e-01 6.1369935194e-09 3.0000000000e-01 6.1412662297e-09 3.6000000000e-01 6.1456284987e-09 4.2000000000e-01 \
 6.1500573281e-09 4.8000000000e-01 6.1546052927e-09 5.4000000000e-01 6.1592498315e-09 6.0000000000e-01 6.1640922657e-09 6.6000000000e-01 6.1691777122e-09 7.2000000000e-01 \
 6.1745121473e-09 7.8000000000e-01 6.1802336794e-09 8.4000000000e-01 6.1868883533e-09 9.0000000000e-01 6.1935430273e-09 9.6000000000e-01 6.2028143955e-09 1.0200000000e+00 \
 6.2144573584e-09 1.0800000000e+00 6.2211479701e-09 1.1040000000e+00 6.2302871809e-09 1.1280000000e+00 6.2394263918e-09 1.1520000000e+00 6.2712608219e-09 1.1760000000e+00 \
 1.0507129661e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  21 6.0200000000e-09 5.0000000000e-12 9.0000000000e-11 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995502e-09 0.0000000000e+00 \
 6.0639515131e-09 2.4000000000e-02 6.1079034760e-09 4.8000000000e-02 6.1198796018e-09 7.2000000000e-02 6.1220887532e-09 9.6000000000e-02 6.1239274768e-09 1.2000000000e-01 \
 6.1285090920e-09 1.8000000000e-01 6.1327688324e-09 2.4000000000e-01 6.1369935194e-09 3.0000000000e-01 6.1412662297e-09 3.6000000000e-01 6.1456284987e-09 4.2000000000e-01 \
 6.1500573281e-09 4.8000000000e-01 6.1546052927e-09 5.4000000000e-01 6.1592498315e-09 6.0000000000e-01 6.1640922657e-09 6.6000000000e-01 6.1691777122e-09 7.2000000000e-01 \
 6.1745121473e-09 7.8000000000e-01 6.1802336794e-09 8.4000000000e-01 6.1868883533e-09 9.0000000000e-01 6.1935430273e-09 9.6000000000e-01 6.2028143955e-09 1.0200000000e+00 \
 6.2144573584e-09 1.0800000000e+00 6.2211479701e-09 1.1040000000e+00 6.2302871809e-09 1.1280000000e+00 6.2394263918e-09 1.1520000000e+00 6.2712608219e-09 1.1760000000e+00 \
 1.0507129661e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  22 6.0200000000e-09 5.0000000000e-12 9.0000000000e-11 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995502e-09 0.0000000000e+00 \
 6.0639515131e-09 2.4000000000e-02 6.1079034760e-09 4.8000000000e-02 6.1198796018e-09 7.2000000000e-02 6.1220887532e-09 9.6000000000e-02 6.1239274768e-09 1.2000000000e-01 \
 6.1285090920e-09 1.8000000000e-01 6.1327688324e-09 2.4000000000e-01 6.1369935194e-09 3.0000000000e-01 6.1412662297e-09 3.6000000000e-01 6.1456284987e-09 4.2000000000e-01 \
 6.1500573281e-09 4.8000000000e-01 6.1546052927e-09 5.4000000000e-01 6.1592498315e-09 6.0000000000e-01 6.1640922657e-09 6.6000000000e-01 6.1691777122e-09 7.2000000000e-01 \
 6.1745121473e-09 7.8000000000e-01 6.1802336794e-09 8.4000000000e-01 6.1868883533e-09 9.0000000000e-01 6.1935430273e-09 9.6000000000e-01 6.2028143955e-09 1.0200000000e+00 \
 6.2144573584e-09 1.0800000000e+00 6.2211479701e-09 1.1040000000e+00 6.2302871809e-09 1.1280000000e+00 6.2394263918e-09 1.1520000000e+00 6.2712608219e-09 1.1760000000e+00 \
 1.0507129661e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  23 6.0200000000e-09 5.0000000000e-12 9.0000000000e-11 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995502e-09 0.0000000000e+00 \
 6.0639515131e-09 2.4000000000e-02 6.1079034760e-09 4.8000000000e-02 6.1198796018e-09 7.2000000000e-02 6.1220887532e-09 9.6000000000e-02 6.1239274768e-09 1.2000000000e-01 \
 6.1285090920e-09 1.8000000000e-01 6.1327688324e-09 2.4000000000e-01 6.1369935194e-09 3.0000000000e-01 6.1412662297e-09 3.6000000000e-01 6.1456284987e-09 4.2000000000e-01 \
 6.1500573281e-09 4.8000000000e-01 6.1546052927e-09 5.4000000000e-01 6.1592498315e-09 6.0000000000e-01 6.1640922657e-09 6.6000000000e-01 6.1691777122e-09 7.2000000000e-01 \
 6.1745121473e-09 7.8000000000e-01 6.1802336794e-09 8.4000000000e-01 6.1868883533e-09 9.0000000000e-01 6.1935430273e-09 9.6000000000e-01 6.2028143955e-09 1.0200000000e+00 \
 6.2144573584e-09 1.0800000000e+00 6.2211479701e-09 1.1040000000e+00 6.2302871809e-09 1.1280000000e+00 6.2394263918e-09 1.1520000000e+00 6.2712608219e-09 1.1760000000e+00 \
 1.0507129661e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  24 6.0200000000e-09 5.0000000000e-12 1.0000000000e-10 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994797e-09 0.0000000000e+00 \
 6.0708324323e-09 2.4000000000e-02 6.1181866939e-09 4.8000000000e-02 6.1207039109e-09 7.2000000000e-02 6.1230052851e-09 9.6000000000e-02 6.1251287986e-09 1.2000000000e-01 \
 6.1299859661e-09 1.8000000000e-01 6.1346687717e-09 2.4000000000e-01 6.1393493045e-09 3.0000000000e-01 6.1440902181e-09 3.6000000000e-01 6.1489336548e-09 4.2000000000e-01 \
 6.1538908865e-09 4.8000000000e-01 6.1589284837e-09 5.4000000000e-01 6.1641255318e-09 6.0000000000e-01 6.1695415710e-09 6.6000000000e-01 6.1750541626e-09 7.2000000000e-01 \
 6.1812601932e-09 7.8000000000e-01 6.1876199051e-09 8.4000000000e-01 6.1945993016e-09 9.0000000000e-01 6.2030748736e-09 9.6000000000e-01 6.2123126040e-09 1.0200000000e+00 \
 6.2255321303e-09 1.0800000000e+00 6.2325284216e-09 1.1040000000e+00 6.2426952449e-09 1.1280000000e+00 6.2528620683e-09 1.1520000000e+00 6.2798353730e-09 1.1760000000e+00 \
 1.0502720642e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  25 6.0200000000e-09 5.0000000000e-12 1.0000000000e-10 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994797e-09 0.0000000000e+00 \
 6.0708324323e-09 2.4000000000e-02 6.1181866939e-09 4.8000000000e-02 6.1207039109e-09 7.2000000000e-02 6.1230052851e-09 9.6000000000e-02 6.1251287986e-09 1.2000000000e-01 \
 6.1299859661e-09 1.8000000000e-01 6.1346687717e-09 2.4000000000e-01 6.1393493045e-09 3.0000000000e-01 6.1440902181e-09 3.6000000000e-01 6.1489336548e-09 4.2000000000e-01 \
 6.1538908865e-09 4.8000000000e-01 6.1589284837e-09 5.4000000000e-01 6.1641255318e-09 6.0000000000e-01 6.1695415710e-09 6.6000000000e-01 6.1750541626e-09 7.2000000000e-01 \
 6.1812601932e-09 7.8000000000e-01 6.1876199051e-09 8.4000000000e-01 6.1945993016e-09 9.0000000000e-01 6.2030748736e-09 9.6000000000e-01 6.2123126040e-09 1.0200000000e+00 \
 6.2255321303e-09 1.0800000000e+00 6.2325284216e-09 1.1040000000e+00 6.2426952449e-09 1.1280000000e+00 6.2528620683e-09 1.1520000000e+00 6.2798353730e-09 1.1760000000e+00 \
 1.0502720642e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  26 6.0200000000e-09 5.0000000000e-12 1.0000000000e-10 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994797e-09 0.0000000000e+00 \
 6.0708324323e-09 2.4000000000e-02 6.1181866939e-09 4.8000000000e-02 6.1207039109e-09 7.2000000000e-02 6.1230052851e-09 9.6000000000e-02 6.1251287986e-09 1.2000000000e-01 \
 6.1299859661e-09 1.8000000000e-01 6.1346687717e-09 2.4000000000e-01 6.1393493045e-09 3.0000000000e-01 6.1440902181e-09 3.6000000000e-01 6.1489336548e-09 4.2000000000e-01 \
 6.1538908865e-09 4.8000000000e-01 6.1589284837e-09 5.4000000000e-01 6.1641255318e-09 6.0000000000e-01 6.1695415710e-09 6.6000000000e-01 6.1750541626e-09 7.2000000000e-01 \
 6.1812601932e-09 7.8000000000e-01 6.1876199051e-09 8.4000000000e-01 6.1945993016e-09 9.0000000000e-01 6.2030748736e-09 9.6000000000e-01 6.2123126040e-09 1.0200000000e+00 \
 6.2255321303e-09 1.0800000000e+00 6.2325284216e-09 1.1040000000e+00 6.2426952449e-09 1.1280000000e+00 6.2528620683e-09 1.1520000000e+00 6.2798353730e-09 1.1760000000e+00 \
 1.0502720642e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  27 6.0200000000e-09 5.0000000000e-12 1.0000000000e-10 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994797e-09 0.0000000000e+00 \
 6.0708324323e-09 2.4000000000e-02 6.1181866939e-09 4.8000000000e-02 6.1207039109e-09 7.2000000000e-02 6.1230052851e-09 9.6000000000e-02 6.1251287986e-09 1.2000000000e-01 \
 6.1299859661e-09 1.8000000000e-01 6.1346687717e-09 2.4000000000e-01 6.1393493045e-09 3.0000000000e-01 6.1440902181e-09 3.6000000000e-01 6.1489336548e-09 4.2000000000e-01 \
 6.1538908865e-09 4.8000000000e-01 6.1589284837e-09 5.4000000000e-01 6.1641255318e-09 6.0000000000e-01 6.1695415710e-09 6.6000000000e-01 6.1750541626e-09 7.2000000000e-01 \
 6.1812601932e-09 7.8000000000e-01 6.1876199051e-09 8.4000000000e-01 6.1945993016e-09 9.0000000000e-01 6.2030748736e-09 9.6000000000e-01 6.2123126040e-09 1.0200000000e+00 \
 6.2255321303e-09 1.0800000000e+00 6.2325284216e-09 1.1040000000e+00 6.2426952449e-09 1.1280000000e+00 6.2528620683e-09 1.1520000000e+00 6.2798353730e-09 1.1760000000e+00 \
 1.0502720642e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  28 6.0200000000e-09 5.0000000000e-12 1.0000000000e-10 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994797e-09 0.0000000000e+00 \
 6.0708324323e-09 2.4000000000e-02 6.1181866939e-09 4.8000000000e-02 6.1207039109e-09 7.2000000000e-02 6.1230052851e-09 9.6000000000e-02 6.1251287986e-09 1.2000000000e-01 \
 6.1299859661e-09 1.8000000000e-01 6.1346687717e-09 2.4000000000e-01 6.1393493045e-09 3.0000000000e-01 6.1440902181e-09 3.6000000000e-01 6.1489336548e-09 4.2000000000e-01 \
 6.1538908865e-09 4.8000000000e-01 6.1589284837e-09 5.4000000000e-01 6.1641255318e-09 6.0000000000e-01 6.1695415710e-09 6.6000000000e-01 6.1750541626e-09 7.2000000000e-01 \
 6.1812601932e-09 7.8000000000e-01 6.1876199051e-09 8.4000000000e-01 6.1945993016e-09 9.0000000000e-01 6.2030748736e-09 9.6000000000e-01 6.2123126040e-09 1.0200000000e+00 \
 6.2255321303e-09 1.0800000000e+00 6.2325284216e-09 1.1040000000e+00 6.2426952449e-09 1.1280000000e+00 6.2528620683e-09 1.1520000000e+00 6.2798353730e-09 1.1760000000e+00 \
 1.0502720642e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  29 6.0200000000e-09 5.0000000000e-12 1.0000000000e-10 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994797e-09 0.0000000000e+00 \
 6.0708324323e-09 2.4000000000e-02 6.1181866939e-09 4.8000000000e-02 6.1207039109e-09 7.2000000000e-02 6.1230052851e-09 9.6000000000e-02 6.1251287986e-09 1.2000000000e-01 \
 6.1299859661e-09 1.8000000000e-01 6.1346687717e-09 2.4000000000e-01 6.1393493045e-09 3.0000000000e-01 6.1440902181e-09 3.6000000000e-01 6.1489336548e-09 4.2000000000e-01 \
 6.1538908865e-09 4.8000000000e-01 6.1589284837e-09 5.4000000000e-01 6.1641255318e-09 6.0000000000e-01 6.1695415710e-09 6.6000000000e-01 6.1750541626e-09 7.2000000000e-01 \
 6.1812601932e-09 7.8000000000e-01 6.1876199051e-09 8.4000000000e-01 6.1945993016e-09 9.0000000000e-01 6.2030748736e-09 9.6000000000e-01 6.2123126040e-09 1.0200000000e+00 \
 6.2255321303e-09 1.0800000000e+00 6.2325284216e-09 1.1040000000e+00 6.2426952449e-09 1.1280000000e+00 6.2528620683e-09 1.1520000000e+00 6.2798353730e-09 1.1760000000e+00 \
 1.0502720642e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  30 6.0200000000e-09 5.0000000000e-12 1.0000000000e-10 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994797e-09 0.0000000000e+00 \
 6.0708324323e-09 2.4000000000e-02 6.1181866939e-09 4.8000000000e-02 6.1207039109e-09 7.2000000000e-02 6.1230052851e-09 9.6000000000e-02 6.1251287986e-09 1.2000000000e-01 \
 6.1299859661e-09 1.8000000000e-01 6.1346687717e-09 2.4000000000e-01 6.1393493045e-09 3.0000000000e-01 6.1440902181e-09 3.6000000000e-01 6.1489336548e-09 4.2000000000e-01 \
 6.1538908865e-09 4.8000000000e-01 6.1589284837e-09 5.4000000000e-01 6.1641255318e-09 6.0000000000e-01 6.1695415710e-09 6.6000000000e-01 6.1750541626e-09 7.2000000000e-01 \
 6.1812601932e-09 7.8000000000e-01 6.1876199051e-09 8.4000000000e-01 6.1945993016e-09 9.0000000000e-01 6.2030748736e-09 9.6000000000e-01 6.2123126040e-09 1.0200000000e+00 \
 6.2255321303e-09 1.0800000000e+00 6.2325284216e-09 1.1040000000e+00 6.2426952449e-09 1.1280000000e+00 6.2528620683e-09 1.1520000000e+00 6.2798353730e-09 1.1760000000e+00 \
 1.0502720642e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  31 6.0200000000e-09 5.0000000000e-12 1.0000000000e-10 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994797e-09 0.0000000000e+00 \
 6.0708324323e-09 2.4000000000e-02 6.1181866939e-09 4.8000000000e-02 6.1207039109e-09 7.2000000000e-02 6.1230052851e-09 9.6000000000e-02 6.1251287986e-09 1.2000000000e-01 \
 6.1299859661e-09 1.8000000000e-01 6.1346687717e-09 2.4000000000e-01 6.1393493045e-09 3.0000000000e-01 6.1440902181e-09 3.6000000000e-01 6.1489336548e-09 4.2000000000e-01 \
 6.1538908865e-09 4.8000000000e-01 6.1589284837e-09 5.4000000000e-01 6.1641255318e-09 6.0000000000e-01 6.1695415710e-09 6.6000000000e-01 6.1750541626e-09 7.2000000000e-01 \
 6.1812601932e-09 7.8000000000e-01 6.1876199051e-09 8.4000000000e-01 6.1945993016e-09 9.0000000000e-01 6.2030748736e-09 9.6000000000e-01 6.2123126040e-09 1.0200000000e+00 \
 6.2255321303e-09 1.0800000000e+00 6.2325284216e-09 1.1040000000e+00 6.2426952449e-09 1.1280000000e+00 6.2528620683e-09 1.1520000000e+00 6.2798353730e-09 1.1760000000e+00 \
 1.0502720642e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  32 6.0200000000e-09 5.0000000000e-12 1.3000000000e-10 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995692e-09 0.0000000000e+00 \
 6.0620924690e-09 2.4000000000e-02 6.1041853689e-09 4.8000000000e-02 6.1228260738e-09 7.2000000000e-02 6.1254959438e-09 9.6000000000e-02 6.1281658137e-09 1.2000000000e-01 \
 6.1342230729e-09 1.8000000000e-01 6.1402193582e-09 2.4000000000e-01 6.1462845791e-09 3.0000000000e-01 6.1524536831e-09 3.6000000000e-01 6.1587264164e-09 4.2000000000e-01 \
 6.1651438115e-09 4.8000000000e-01 6.1717746997e-09 5.4000000000e-01 6.1785071821e-09 6.0000000000e-01 6.1856792120e-09 6.6000000000e-01 6.1928512418e-09 7.2000000000e-01 \
 6.2011712479e-09 7.8000000000e-01 6.2100166798e-09 8.4000000000e-01 6.2188621117e-09 9.0000000000e-01 6.2290807944e-09 9.6000000000e-01 6.2418137911e-09 1.0200000000e+00 \
 6.2581859925e-09 1.0800000000e+00 6.2685055203e-09 1.1040000000e+00 6.2788913451e-09 1.1280000000e+00 6.3008168645e-09 1.1520000000e+00 6.3246247275e-09 1.1760000000e+00 \
 1.0501115260e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  33 6.0200000000e-09 5.0000000000e-12 1.3000000000e-10 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995692e-09 0.0000000000e+00 \
 6.0620924690e-09 2.4000000000e-02 6.1041853689e-09 4.8000000000e-02 6.1228260738e-09 7.2000000000e-02 6.1254959438e-09 9.6000000000e-02 6.1281658137e-09 1.2000000000e-01 \
 6.1342230729e-09 1.8000000000e-01 6.1402193582e-09 2.4000000000e-01 6.1462845791e-09 3.0000000000e-01 6.1524536831e-09 3.6000000000e-01 6.1587264164e-09 4.2000000000e-01 \
 6.1651438115e-09 4.8000000000e-01 6.1717746997e-09 5.4000000000e-01 6.1785071821e-09 6.0000000000e-01 6.1856792120e-09 6.6000000000e-01 6.1928512418e-09 7.2000000000e-01 \
 6.2011712479e-09 7.8000000000e-01 6.2100166798e-09 8.4000000000e-01 6.2188621117e-09 9.0000000000e-01 6.2290807944e-09 9.6000000000e-01 6.2418137911e-09 1.0200000000e+00 \
 6.2581859925e-09 1.0800000000e+00 6.2685055203e-09 1.1040000000e+00 6.2788913451e-09 1.1280000000e+00 6.3008168645e-09 1.1520000000e+00 6.3246247275e-09 1.1760000000e+00 \
 1.0501115260e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  34 6.0200000000e-09 5.0000000000e-12 1.3000000000e-10 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995692e-09 0.0000000000e+00 \
 6.0620924690e-09 2.4000000000e-02 6.1041853689e-09 4.8000000000e-02 6.1228260738e-09 7.2000000000e-02 6.1254959438e-09 9.6000000000e-02 6.1281658137e-09 1.2000000000e-01 \
 6.1342230729e-09 1.8000000000e-01 6.1402193582e-09 2.4000000000e-01 6.1462845791e-09 3.0000000000e-01 6.1524536831e-09 3.6000000000e-01 6.1587264164e-09 4.2000000000e-01 \
 6.1651438115e-09 4.8000000000e-01 6.1717746997e-09 5.4000000000e-01 6.1785071821e-09 6.0000000000e-01 6.1856792120e-09 6.6000000000e-01 6.1928512418e-09 7.2000000000e-01 \
 6.2011712479e-09 7.8000000000e-01 6.2100166798e-09 8.4000000000e-01 6.2188621117e-09 9.0000000000e-01 6.2290807944e-09 9.6000000000e-01 6.2418137911e-09 1.0200000000e+00 \
 6.2581859925e-09 1.0800000000e+00 6.2685055203e-09 1.1040000000e+00 6.2788913451e-09 1.1280000000e+00 6.3008168645e-09 1.1520000000e+00 6.3246247275e-09 1.1760000000e+00 \
 1.0501115260e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  35 6.0200000000e-09 5.0000000000e-12 1.3000000000e-10 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995692e-09 0.0000000000e+00 \
 6.0620924690e-09 2.4000000000e-02 6.1041853689e-09 4.8000000000e-02 6.1228260738e-09 7.2000000000e-02 6.1254959438e-09 9.6000000000e-02 6.1281658137e-09 1.2000000000e-01 \
 6.1342230729e-09 1.8000000000e-01 6.1402193582e-09 2.4000000000e-01 6.1462845791e-09 3.0000000000e-01 6.1524536831e-09 3.6000000000e-01 6.1587264164e-09 4.2000000000e-01 \
 6.1651438115e-09 4.8000000000e-01 6.1717746997e-09 5.4000000000e-01 6.1785071821e-09 6.0000000000e-01 6.1856792120e-09 6.6000000000e-01 6.1928512418e-09 7.2000000000e-01 \
 6.2011712479e-09 7.8000000000e-01 6.2100166798e-09 8.4000000000e-01 6.2188621117e-09 9.0000000000e-01 6.2290807944e-09 9.6000000000e-01 6.2418137911e-09 1.0200000000e+00 \
 6.2581859925e-09 1.0800000000e+00 6.2685055203e-09 1.1040000000e+00 6.2788913451e-09 1.1280000000e+00 6.3008168645e-09 1.1520000000e+00 6.3246247275e-09 1.1760000000e+00 \
 1.0501115260e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  36 6.0200000000e-09 5.0000000000e-12 1.3000000000e-10 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995692e-09 0.0000000000e+00 \
 6.0620924690e-09 2.4000000000e-02 6.1041853689e-09 4.8000000000e-02 6.1228260738e-09 7.2000000000e-02 6.1254959438e-09 9.6000000000e-02 6.1281658137e-09 1.2000000000e-01 \
 6.1342230729e-09 1.8000000000e-01 6.1402193582e-09 2.4000000000e-01 6.1462845791e-09 3.0000000000e-01 6.1524536831e-09 3.6000000000e-01 6.1587264164e-09 4.2000000000e-01 \
 6.1651438115e-09 4.8000000000e-01 6.1717746997e-09 5.4000000000e-01 6.1785071821e-09 6.0000000000e-01 6.1856792120e-09 6.6000000000e-01 6.1928512418e-09 7.2000000000e-01 \
 6.2011712479e-09 7.8000000000e-01 6.2100166798e-09 8.4000000000e-01 6.2188621117e-09 9.0000000000e-01 6.2290807944e-09 9.6000000000e-01 6.2418137911e-09 1.0200000000e+00 \
 6.2581859925e-09 1.0800000000e+00 6.2685055203e-09 1.1040000000e+00 6.2788913451e-09 1.1280000000e+00 6.3008168645e-09 1.1520000000e+00 6.3246247275e-09 1.1760000000e+00 \
 1.0501115260e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  37 6.0200000000e-09 5.0000000000e-12 1.3000000000e-10 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995692e-09 0.0000000000e+00 \
 6.0620924690e-09 2.4000000000e-02 6.1041853689e-09 4.8000000000e-02 6.1228260738e-09 7.2000000000e-02 6.1254959438e-09 9.6000000000e-02 6.1281658137e-09 1.2000000000e-01 \
 6.1342230729e-09 1.8000000000e-01 6.1402193582e-09 2.4000000000e-01 6.1462845791e-09 3.0000000000e-01 6.1524536831e-09 3.6000000000e-01 6.1587264164e-09 4.2000000000e-01 \
 6.1651438115e-09 4.8000000000e-01 6.1717746997e-09 5.4000000000e-01 6.1785071821e-09 6.0000000000e-01 6.1856792120e-09 6.6000000000e-01 6.1928512418e-09 7.2000000000e-01 \
 6.2011712479e-09 7.8000000000e-01 6.2100166798e-09 8.4000000000e-01 6.2188621117e-09 9.0000000000e-01 6.2290807944e-09 9.6000000000e-01 6.2418137911e-09 1.0200000000e+00 \
 6.2581859925e-09 1.0800000000e+00 6.2685055203e-09 1.1040000000e+00 6.2788913451e-09 1.1280000000e+00 6.3008168645e-09 1.1520000000e+00 6.3246247275e-09 1.1760000000e+00 \
 1.0501115260e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  38 6.0200000000e-09 5.0000000000e-12 1.3000000000e-10 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995692e-09 0.0000000000e+00 \
 6.0620924690e-09 2.4000000000e-02 6.1041853689e-09 4.8000000000e-02 6.1228260738e-09 7.2000000000e-02 6.1254959438e-09 9.6000000000e-02 6.1281658137e-09 1.2000000000e-01 \
 6.1342230729e-09 1.8000000000e-01 6.1402193582e-09 2.4000000000e-01 6.1462845791e-09 3.0000000000e-01 6.1524536831e-09 3.6000000000e-01 6.1587264164e-09 4.2000000000e-01 \
 6.1651438115e-09 4.8000000000e-01 6.1717746997e-09 5.4000000000e-01 6.1785071821e-09 6.0000000000e-01 6.1856792120e-09 6.6000000000e-01 6.1928512418e-09 7.2000000000e-01 \
 6.2011712479e-09 7.8000000000e-01 6.2100166798e-09 8.4000000000e-01 6.2188621117e-09 9.0000000000e-01 6.2290807944e-09 9.6000000000e-01 6.2418137911e-09 1.0200000000e+00 \
 6.2581859925e-09 1.0800000000e+00 6.2685055203e-09 1.1040000000e+00 6.2788913451e-09 1.1280000000e+00 6.3008168645e-09 1.1520000000e+00 6.3246247275e-09 1.1760000000e+00 \
 1.0501115260e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  39 6.0200000000e-09 5.0000000000e-12 1.3000000000e-10 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995692e-09 0.0000000000e+00 \
 6.0620924690e-09 2.4000000000e-02 6.1041853689e-09 4.8000000000e-02 6.1228260738e-09 7.2000000000e-02 6.1254959438e-09 9.6000000000e-02 6.1281658137e-09 1.2000000000e-01 \
 6.1342230729e-09 1.8000000000e-01 6.1402193582e-09 2.4000000000e-01 6.1462845791e-09 3.0000000000e-01 6.1524536831e-09 3.6000000000e-01 6.1587264164e-09 4.2000000000e-01 \
 6.1651438115e-09 4.8000000000e-01 6.1717746997e-09 5.4000000000e-01 6.1785071821e-09 6.0000000000e-01 6.1856792120e-09 6.6000000000e-01 6.1928512418e-09 7.2000000000e-01 \
 6.2011712479e-09 7.8000000000e-01 6.2100166798e-09 8.4000000000e-01 6.2188621117e-09 9.0000000000e-01 6.2290807944e-09 9.6000000000e-01 6.2418137911e-09 1.0200000000e+00 \
 6.2581859925e-09 1.0800000000e+00 6.2685055203e-09 1.1040000000e+00 6.2788913451e-09 1.1280000000e+00 6.3008168645e-09 1.1520000000e+00 6.3246247275e-09 1.1760000000e+00 \
 1.0501115260e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  40 6.0200000000e-09 5.0000000000e-12 1.5000000000e-10 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994834e-09 0.0000000000e+00 \
 6.0704751112e-09 2.4000000000e-02 6.1209507389e-09 4.8000000000e-02 6.1240580859e-09 7.2000000000e-02 6.1271127847e-09 9.6000000000e-02 6.1300559905e-09 1.2000000000e-01 \
 6.1369503265e-09 1.8000000000e-01 6.1438373348e-09 2.4000000000e-01 6.1508218708e-09 3.0000000000e-01 6.1579176965e-09 3.6000000000e-01 6.1651563150e-09 4.2000000000e-01 \
 6.1725813993e-09 4.8000000000e-01 6.1801298340e-09 5.4000000000e-01 6.1881130339e-09 6.0000000000e-01 6.1961750508e-09 6.6000000000e-01 6.2048387539e-09 7.2000000000e-01 \
 6.2148680251e-09 7.8000000000e-01 6.2248972963e-09 8.4000000000e-01 6.2349265675e-09 9.0000000000e-01 6.2465064652e-09 9.6000000000e-01 6.2611726576e-09 1.0200000000e+00 \
 6.2800908171e-09 1.0800000000e+00 6.2920069146e-09 1.1040000000e+00 6.3040001716e-09 1.1280000000e+00 6.3292969190e-09 1.1520000000e+00 6.3572055198e-09 1.1760000000e+00 \
 1.0501508990e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  41 6.0200000000e-09 5.0000000000e-12 1.5000000000e-10 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994834e-09 0.0000000000e+00 \
 6.0704751112e-09 2.4000000000e-02 6.1209507389e-09 4.8000000000e-02 6.1240580859e-09 7.2000000000e-02 6.1271127847e-09 9.6000000000e-02 6.1300559905e-09 1.2000000000e-01 \
 6.1369503265e-09 1.8000000000e-01 6.1438373348e-09 2.4000000000e-01 6.1508218708e-09 3.0000000000e-01 6.1579176965e-09 3.6000000000e-01 6.1651563150e-09 4.2000000000e-01 \
 6.1725813993e-09 4.8000000000e-01 6.1801298340e-09 5.4000000000e-01 6.1881130339e-09 6.0000000000e-01 6.1961750508e-09 6.6000000000e-01 6.2048387539e-09 7.2000000000e-01 \
 6.2148680251e-09 7.8000000000e-01 6.2248972963e-09 8.4000000000e-01 6.2349265675e-09 9.0000000000e-01 6.2465064652e-09 9.6000000000e-01 6.2611726576e-09 1.0200000000e+00 \
 6.2800908171e-09 1.0800000000e+00 6.2920069146e-09 1.1040000000e+00 6.3040001716e-09 1.1280000000e+00 6.3292969190e-09 1.1520000000e+00 6.3572055198e-09 1.1760000000e+00 \
 1.0501508990e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  42 6.0200000000e-09 5.0000000000e-12 1.5000000000e-10 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994834e-09 0.0000000000e+00 \
 6.0704751112e-09 2.4000000000e-02 6.1209507389e-09 4.8000000000e-02 6.1240580859e-09 7.2000000000e-02 6.1271127847e-09 9.6000000000e-02 6.1300559905e-09 1.2000000000e-01 \
 6.1369503265e-09 1.8000000000e-01 6.1438373348e-09 2.4000000000e-01 6.1508218708e-09 3.0000000000e-01 6.1579176965e-09 3.6000000000e-01 6.1651563150e-09 4.2000000000e-01 \
 6.1725813993e-09 4.8000000000e-01 6.1801298340e-09 5.4000000000e-01 6.1881130339e-09 6.0000000000e-01 6.1961750508e-09 6.6000000000e-01 6.2048387539e-09 7.2000000000e-01 \
 6.2148680251e-09 7.8000000000e-01 6.2248972963e-09 8.4000000000e-01 6.2349265675e-09 9.0000000000e-01 6.2465064652e-09 9.6000000000e-01 6.2611726576e-09 1.0200000000e+00 \
 6.2800908171e-09 1.0800000000e+00 6.2920069146e-09 1.1040000000e+00 6.3040001716e-09 1.1280000000e+00 6.3292969190e-09 1.1520000000e+00 6.3572055198e-09 1.1760000000e+00 \
 1.0501508990e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  43 6.0200000000e-09 5.0000000000e-12 1.5000000000e-10 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994834e-09 0.0000000000e+00 \
 6.0704751112e-09 2.4000000000e-02 6.1209507389e-09 4.8000000000e-02 6.1240580859e-09 7.2000000000e-02 6.1271127847e-09 9.6000000000e-02 6.1300559905e-09 1.2000000000e-01 \
 6.1369503265e-09 1.8000000000e-01 6.1438373348e-09 2.4000000000e-01 6.1508218708e-09 3.0000000000e-01 6.1579176965e-09 3.6000000000e-01 6.1651563150e-09 4.2000000000e-01 \
 6.1725813993e-09 4.8000000000e-01 6.1801298340e-09 5.4000000000e-01 6.1881130339e-09 6.0000000000e-01 6.1961750508e-09 6.6000000000e-01 6.2048387539e-09 7.2000000000e-01 \
 6.2148680251e-09 7.8000000000e-01 6.2248972963e-09 8.4000000000e-01 6.2349265675e-09 9.0000000000e-01 6.2465064652e-09 9.6000000000e-01 6.2611726576e-09 1.0200000000e+00 \
 6.2800908171e-09 1.0800000000e+00 6.2920069146e-09 1.1040000000e+00 6.3040001716e-09 1.1280000000e+00 6.3292969190e-09 1.1520000000e+00 6.3572055198e-09 1.1760000000e+00 \
 1.0501508990e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  44 6.0200000000e-09 5.0000000000e-12 1.5000000000e-10 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994834e-09 0.0000000000e+00 \
 6.0704751112e-09 2.4000000000e-02 6.1209507389e-09 4.8000000000e-02 6.1240580859e-09 7.2000000000e-02 6.1271127847e-09 9.6000000000e-02 6.1300559905e-09 1.2000000000e-01 \
 6.1369503265e-09 1.8000000000e-01 6.1438373348e-09 2.4000000000e-01 6.1508218708e-09 3.0000000000e-01 6.1579176965e-09 3.6000000000e-01 6.1651563150e-09 4.2000000000e-01 \
 6.1725813993e-09 4.8000000000e-01 6.1801298340e-09 5.4000000000e-01 6.1881130339e-09 6.0000000000e-01 6.1961750508e-09 6.6000000000e-01 6.2048387539e-09 7.2000000000e-01 \
 6.2148680251e-09 7.8000000000e-01 6.2248972963e-09 8.4000000000e-01 6.2349265675e-09 9.0000000000e-01 6.2465064652e-09 9.6000000000e-01 6.2611726576e-09 1.0200000000e+00 \
 6.2800908171e-09 1.0800000000e+00 6.2920069146e-09 1.1040000000e+00 6.3040001716e-09 1.1280000000e+00 6.3292969190e-09 1.1520000000e+00 6.3572055198e-09 1.1760000000e+00 \
 1.0501508990e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  45 6.0200000000e-09 5.0000000000e-12 1.5000000000e-10 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994834e-09 0.0000000000e+00 \
 6.0704751112e-09 2.4000000000e-02 6.1209507389e-09 4.8000000000e-02 6.1240580859e-09 7.2000000000e-02 6.1271127847e-09 9.6000000000e-02 6.1300559905e-09 1.2000000000e-01 \
 6.1369503265e-09 1.8000000000e-01 6.1438373348e-09 2.4000000000e-01 6.1508218708e-09 3.0000000000e-01 6.1579176965e-09 3.6000000000e-01 6.1651563150e-09 4.2000000000e-01 \
 6.1725813993e-09 4.8000000000e-01 6.1801298340e-09 5.4000000000e-01 6.1881130339e-09 6.0000000000e-01 6.1961750508e-09 6.6000000000e-01 6.2048387539e-09 7.2000000000e-01 \
 6.2148680251e-09 7.8000000000e-01 6.2248972963e-09 8.4000000000e-01 6.2349265675e-09 9.0000000000e-01 6.2465064652e-09 9.6000000000e-01 6.2611726576e-09 1.0200000000e+00 \
 6.2800908171e-09 1.0800000000e+00 6.2920069146e-09 1.1040000000e+00 6.3040001716e-09 1.1280000000e+00 6.3292969190e-09 1.1520000000e+00 6.3572055198e-09 1.1760000000e+00 \
 1.0501508990e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  46 6.0200000000e-09 5.0000000000e-12 1.5000000000e-10 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994834e-09 0.0000000000e+00 \
 6.0704751112e-09 2.4000000000e-02 6.1209507389e-09 4.8000000000e-02 6.1240580859e-09 7.2000000000e-02 6.1271127847e-09 9.6000000000e-02 6.1300559905e-09 1.2000000000e-01 \
 6.1369503265e-09 1.8000000000e-01 6.1438373348e-09 2.4000000000e-01 6.1508218708e-09 3.0000000000e-01 6.1579176965e-09 3.6000000000e-01 6.1651563150e-09 4.2000000000e-01 \
 6.1725813993e-09 4.8000000000e-01 6.1801298340e-09 5.4000000000e-01 6.1881130339e-09 6.0000000000e-01 6.1961750508e-09 6.6000000000e-01 6.2048387539e-09 7.2000000000e-01 \
 6.2148680251e-09 7.8000000000e-01 6.2248972963e-09 8.4000000000e-01 6.2349265675e-09 9.0000000000e-01 6.2465064652e-09 9.6000000000e-01 6.2611726576e-09 1.0200000000e+00 \
 6.2800908171e-09 1.0800000000e+00 6.2920069146e-09 1.1040000000e+00 6.3040001716e-09 1.1280000000e+00 6.3292969190e-09 1.1520000000e+00 6.3572055198e-09 1.1760000000e+00 \
 1.0501508990e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  47 6.0200000000e-09 5.0000000000e-12 1.5000000000e-10 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994834e-09 0.0000000000e+00 \
 6.0704751112e-09 2.4000000000e-02 6.1209507389e-09 4.8000000000e-02 6.1240580859e-09 7.2000000000e-02 6.1271127847e-09 9.6000000000e-02 6.1300559905e-09 1.2000000000e-01 \
 6.1369503265e-09 1.8000000000e-01 6.1438373348e-09 2.4000000000e-01 6.1508218708e-09 3.0000000000e-01 6.1579176965e-09 3.6000000000e-01 6.1651563150e-09 4.2000000000e-01 \
 6.1725813993e-09 4.8000000000e-01 6.1801298340e-09 5.4000000000e-01 6.1881130339e-09 6.0000000000e-01 6.1961750508e-09 6.6000000000e-01 6.2048387539e-09 7.2000000000e-01 \
 6.2148680251e-09 7.8000000000e-01 6.2248972963e-09 8.4000000000e-01 6.2349265675e-09 9.0000000000e-01 6.2465064652e-09 9.6000000000e-01 6.2611726576e-09 1.0200000000e+00 \
 6.2800908171e-09 1.0800000000e+00 6.2920069146e-09 1.1040000000e+00 6.3040001716e-09 1.1280000000e+00 6.3292969190e-09 1.1520000000e+00 6.3572055198e-09 1.1760000000e+00 \
 1.0501508990e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  48 6.0200000000e-09 5.0000000000e-12 1.7000000000e-10 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993943e-09 0.0000000000e+00 \
 6.0791796976e-09 2.4000000000e-02 6.1218637184e-09 4.8000000000e-02 6.1253449734e-09 7.2000000000e-02 6.1288170866e-09 9.6000000000e-02 6.1319399827e-09 1.2000000000e-01 \
 6.1397189848e-09 1.8000000000e-01 6.1475122454e-09 2.4000000000e-01 6.1554396971e-09 3.0000000000e-01 6.1634915967e-09 3.6000000000e-01 6.1717133252e-09 4.2000000000e-01 \
 6.1801187569e-09 4.8000000000e-01 6.1888562037e-09 5.4000000000e-01 6.1977303331e-09 6.0000000000e-01 6.2069936905e-09 6.6000000000e-01 6.2170852338e-09 7.2000000000e-01 \
 6.2271767771e-09 7.8000000000e-01 6.2375853905e-09 8.4000000000e-01 6.2509325847e-09 9.0000000000e-01 6.2642797788e-09 9.6000000000e-01 6.2805277516e-09 1.0200000000e+00 \
 6.3023708441e-09 1.0800000000e+00 6.3150362479e-09 1.1040000000e+00 6.3294358596e-09 1.1280000000e+00 6.3572667357e-09 1.1520000000e+00 6.3900378826e-09 1.1760000000e+00 \
 1.0501847774e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  49 6.0200000000e-09 5.0000000000e-12 1.7000000000e-10 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993943e-09 0.0000000000e+00 \
 6.0791796976e-09 2.4000000000e-02 6.1218637184e-09 4.8000000000e-02 6.1253449734e-09 7.2000000000e-02 6.1288170866e-09 9.6000000000e-02 6.1319399827e-09 1.2000000000e-01 \
 6.1397189848e-09 1.8000000000e-01 6.1475122454e-09 2.4000000000e-01 6.1554396971e-09 3.0000000000e-01 6.1634915967e-09 3.6000000000e-01 6.1717133252e-09 4.2000000000e-01 \
 6.1801187569e-09 4.8000000000e-01 6.1888562037e-09 5.4000000000e-01 6.1977303331e-09 6.0000000000e-01 6.2069936905e-09 6.6000000000e-01 6.2170852338e-09 7.2000000000e-01 \
 6.2271767771e-09 7.8000000000e-01 6.2375853905e-09 8.4000000000e-01 6.2509325847e-09 9.0000000000e-01 6.2642797788e-09 9.6000000000e-01 6.2805277516e-09 1.0200000000e+00 \
 6.3023708441e-09 1.0800000000e+00 6.3150362479e-09 1.1040000000e+00 6.3294358596e-09 1.1280000000e+00 6.3572667357e-09 1.1520000000e+00 6.3900378826e-09 1.1760000000e+00 \
 1.0501847774e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  50 6.0200000000e-09 5.0000000000e-12 1.7000000000e-10 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993943e-09 0.0000000000e+00 \
 6.0791796976e-09 2.4000000000e-02 6.1218637184e-09 4.8000000000e-02 6.1253449734e-09 7.2000000000e-02 6.1288170866e-09 9.6000000000e-02 6.1319399827e-09 1.2000000000e-01 \
 6.1397189848e-09 1.8000000000e-01 6.1475122454e-09 2.4000000000e-01 6.1554396971e-09 3.0000000000e-01 6.1634915967e-09 3.6000000000e-01 6.1717133252e-09 4.2000000000e-01 \
 6.1801187569e-09 4.8000000000e-01 6.1888562037e-09 5.4000000000e-01 6.1977303331e-09 6.0000000000e-01 6.2069936905e-09 6.6000000000e-01 6.2170852338e-09 7.2000000000e-01 \
 6.2271767771e-09 7.8000000000e-01 6.2375853905e-09 8.4000000000e-01 6.2509325847e-09 9.0000000000e-01 6.2642797788e-09 9.6000000000e-01 6.2805277516e-09 1.0200000000e+00 \
 6.3023708441e-09 1.0800000000e+00 6.3150362479e-09 1.1040000000e+00 6.3294358596e-09 1.1280000000e+00 6.3572667357e-09 1.1520000000e+00 6.3900378826e-09 1.1760000000e+00 \
 1.0501847774e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  51 6.0200000000e-09 5.0000000000e-12 1.7000000000e-10 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993943e-09 0.0000000000e+00 \
 6.0791796976e-09 2.4000000000e-02 6.1218637184e-09 4.8000000000e-02 6.1253449734e-09 7.2000000000e-02 6.1288170866e-09 9.6000000000e-02 6.1319399827e-09 1.2000000000e-01 \
 6.1397189848e-09 1.8000000000e-01 6.1475122454e-09 2.4000000000e-01 6.1554396971e-09 3.0000000000e-01 6.1634915967e-09 3.6000000000e-01 6.1717133252e-09 4.2000000000e-01 \
 6.1801187569e-09 4.8000000000e-01 6.1888562037e-09 5.4000000000e-01 6.1977303331e-09 6.0000000000e-01 6.2069936905e-09 6.6000000000e-01 6.2170852338e-09 7.2000000000e-01 \
 6.2271767771e-09 7.8000000000e-01 6.2375853905e-09 8.4000000000e-01 6.2509325847e-09 9.0000000000e-01 6.2642797788e-09 9.6000000000e-01 6.2805277516e-09 1.0200000000e+00 \
 6.3023708441e-09 1.0800000000e+00 6.3150362479e-09 1.1040000000e+00 6.3294358596e-09 1.1280000000e+00 6.3572667357e-09 1.1520000000e+00 6.3900378826e-09 1.1760000000e+00 \
 1.0501847774e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  52 6.0200000000e-09 5.0000000000e-12 1.7000000000e-10 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993943e-09 0.0000000000e+00 \
 6.0791796976e-09 2.4000000000e-02 6.1218637184e-09 4.8000000000e-02 6.1253449734e-09 7.2000000000e-02 6.1288170866e-09 9.6000000000e-02 6.1319399827e-09 1.2000000000e-01 \
 6.1397189848e-09 1.8000000000e-01 6.1475122454e-09 2.4000000000e-01 6.1554396971e-09 3.0000000000e-01 6.1634915967e-09 3.6000000000e-01 6.1717133252e-09 4.2000000000e-01 \
 6.1801187569e-09 4.8000000000e-01 6.1888562037e-09 5.4000000000e-01 6.1977303331e-09 6.0000000000e-01 6.2069936905e-09 6.6000000000e-01 6.2170852338e-09 7.2000000000e-01 \
 6.2271767771e-09 7.8000000000e-01 6.2375853905e-09 8.4000000000e-01 6.2509325847e-09 9.0000000000e-01 6.2642797788e-09 9.6000000000e-01 6.2805277516e-09 1.0200000000e+00 \
 6.3023708441e-09 1.0800000000e+00 6.3150362479e-09 1.1040000000e+00 6.3294358596e-09 1.1280000000e+00 6.3572667357e-09 1.1520000000e+00 6.3900378826e-09 1.1760000000e+00 \
 1.0501847774e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  53 6.0200000000e-09 5.0000000000e-12 1.7000000000e-10 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993943e-09 0.0000000000e+00 \
 6.0791796976e-09 2.4000000000e-02 6.1218637184e-09 4.8000000000e-02 6.1253449734e-09 7.2000000000e-02 6.1288170866e-09 9.6000000000e-02 6.1319399827e-09 1.2000000000e-01 \
 6.1397189848e-09 1.8000000000e-01 6.1475122454e-09 2.4000000000e-01 6.1554396971e-09 3.0000000000e-01 6.1634915967e-09 3.6000000000e-01 6.1717133252e-09 4.2000000000e-01 \
 6.1801187569e-09 4.8000000000e-01 6.1888562037e-09 5.4000000000e-01 6.1977303331e-09 6.0000000000e-01 6.2069936905e-09 6.6000000000e-01 6.2170852338e-09 7.2000000000e-01 \
 6.2271767771e-09 7.8000000000e-01 6.2375853905e-09 8.4000000000e-01 6.2509325847e-09 9.0000000000e-01 6.2642797788e-09 9.6000000000e-01 6.2805277516e-09 1.0200000000e+00 \
 6.3023708441e-09 1.0800000000e+00 6.3150362479e-09 1.1040000000e+00 6.3294358596e-09 1.1280000000e+00 6.3572667357e-09 1.1520000000e+00 6.3900378826e-09 1.1760000000e+00 \
 1.0501847774e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  54 6.0200000000e-09 5.0000000000e-12 1.7000000000e-10 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993943e-09 0.0000000000e+00 \
 6.0791796976e-09 2.4000000000e-02 6.1218637184e-09 4.8000000000e-02 6.1253449734e-09 7.2000000000e-02 6.1288170866e-09 9.6000000000e-02 6.1319399827e-09 1.2000000000e-01 \
 6.1397189848e-09 1.8000000000e-01 6.1475122454e-09 2.4000000000e-01 6.1554396971e-09 3.0000000000e-01 6.1634915967e-09 3.6000000000e-01 6.1717133252e-09 4.2000000000e-01 \
 6.1801187569e-09 4.8000000000e-01 6.1888562037e-09 5.4000000000e-01 6.1977303331e-09 6.0000000000e-01 6.2069936905e-09 6.6000000000e-01 6.2170852338e-09 7.2000000000e-01 \
 6.2271767771e-09 7.8000000000e-01 6.2375853905e-09 8.4000000000e-01 6.2509325847e-09 9.0000000000e-01 6.2642797788e-09 9.6000000000e-01 6.2805277516e-09 1.0200000000e+00 \
 6.3023708441e-09 1.0800000000e+00 6.3150362479e-09 1.1040000000e+00 6.3294358596e-09 1.1280000000e+00 6.3572667357e-09 1.1520000000e+00 6.3900378826e-09 1.1760000000e+00 \
 1.0501847774e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  55 6.0200000000e-09 5.0000000000e-12 1.7000000000e-10 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993943e-09 0.0000000000e+00 \
 6.0791796976e-09 2.4000000000e-02 6.1218637184e-09 4.8000000000e-02 6.1253449734e-09 7.2000000000e-02 6.1288170866e-09 9.6000000000e-02 6.1319399827e-09 1.2000000000e-01 \
 6.1397189848e-09 1.8000000000e-01 6.1475122454e-09 2.4000000000e-01 6.1554396971e-09 3.0000000000e-01 6.1634915967e-09 3.6000000000e-01 6.1717133252e-09 4.2000000000e-01 \
 6.1801187569e-09 4.8000000000e-01 6.1888562037e-09 5.4000000000e-01 6.1977303331e-09 6.0000000000e-01 6.2069936905e-09 6.6000000000e-01 6.2170852338e-09 7.2000000000e-01 \
 6.2271767771e-09 7.8000000000e-01 6.2375853905e-09 8.4000000000e-01 6.2509325847e-09 9.0000000000e-01 6.2642797788e-09 9.6000000000e-01 6.2805277516e-09 1.0200000000e+00 \
 6.3023708441e-09 1.0800000000e+00 6.3150362479e-09 1.1040000000e+00 6.3294358596e-09 1.1280000000e+00 6.3572667357e-09 1.1520000000e+00 6.3900378826e-09 1.1760000000e+00 \
 1.0501847774e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  56 6.0200000000e-09 5.0000000000e-12 1.9000000000e-10 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995501e-09 0.0000000000e+00 \
 6.0639594572e-09 2.4000000000e-02 6.1079193643e-09 4.8000000000e-02 6.1266434347e-09 7.2000000000e-02 6.1302391510e-09 9.6000000000e-02 6.1338080444e-09 1.2000000000e-01 \
 6.1424250603e-09 1.8000000000e-01 6.1511316325e-09 2.4000000000e-01 6.1599696259e-09 3.0000000000e-01 6.1689607376e-09 3.6000000000e-01 6.1781649427e-09 4.2000000000e-01 \
 6.1875295760e-09 4.8000000000e-01 6.1973663714e-09 5.4000000000e-01 6.2073069224e-09 6.0000000000e-01 6.2175403630e-09 6.6000000000e-01 6.2296995297e-09 7.2000000000e-01 \
 6.2418586965e-09 7.8000000000e-01 6.2540178632e-09 8.4000000000e-01 6.2661770299e-09 9.0000000000e-01 6.2823876978e-09 9.6000000000e-01 6.3000424812e-09 1.0200000000e+00 \
 6.3249107525e-09 1.0800000000e+00 6.3374444557e-09 1.1040000000e+00 6.3577749493e-09 1.1280000000e+00 6.3781678891e-09 1.1520000000e+00 6.4449725488e-09 1.1760000000e+00 \
 1.0506482821e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  57 6.0200000000e-09 5.0000000000e-12 1.9000000000e-10 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995501e-09 0.0000000000e+00 \
 6.0639594572e-09 2.4000000000e-02 6.1079193643e-09 4.8000000000e-02 6.1266434347e-09 7.2000000000e-02 6.1302391510e-09 9.6000000000e-02 6.1338080444e-09 1.2000000000e-01 \
 6.1424250603e-09 1.8000000000e-01 6.1511316325e-09 2.4000000000e-01 6.1599696259e-09 3.0000000000e-01 6.1689607376e-09 3.6000000000e-01 6.1781649427e-09 4.2000000000e-01 \
 6.1875295760e-09 4.8000000000e-01 6.1973663714e-09 5.4000000000e-01 6.2073069224e-09 6.0000000000e-01 6.2175403630e-09 6.6000000000e-01 6.2296995297e-09 7.2000000000e-01 \
 6.2418586965e-09 7.8000000000e-01 6.2540178632e-09 8.4000000000e-01 6.2661770299e-09 9.0000000000e-01 6.2823876978e-09 9.6000000000e-01 6.3000424812e-09 1.0200000000e+00 \
 6.3249107525e-09 1.0800000000e+00 6.3374444557e-09 1.1040000000e+00 6.3577749493e-09 1.1280000000e+00 6.3781678891e-09 1.1520000000e+00 6.4449725488e-09 1.1760000000e+00 \
 1.0506482821e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  58 6.0200000000e-09 5.0000000000e-12 1.9000000000e-10 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995501e-09 0.0000000000e+00 \
 6.0639594572e-09 2.4000000000e-02 6.1079193643e-09 4.8000000000e-02 6.1266434347e-09 7.2000000000e-02 6.1302391510e-09 9.6000000000e-02 6.1338080444e-09 1.2000000000e-01 \
 6.1424250603e-09 1.8000000000e-01 6.1511316325e-09 2.4000000000e-01 6.1599696259e-09 3.0000000000e-01 6.1689607376e-09 3.6000000000e-01 6.1781649427e-09 4.2000000000e-01 \
 6.1875295760e-09 4.8000000000e-01 6.1973663714e-09 5.4000000000e-01 6.2073069224e-09 6.0000000000e-01 6.2175403630e-09 6.6000000000e-01 6.2296995297e-09 7.2000000000e-01 \
 6.2418586965e-09 7.8000000000e-01 6.2540178632e-09 8.4000000000e-01 6.2661770299e-09 9.0000000000e-01 6.2823876978e-09 9.6000000000e-01 6.3000424812e-09 1.0200000000e+00 \
 6.3249107525e-09 1.0800000000e+00 6.3374444557e-09 1.1040000000e+00 6.3577749493e-09 1.1280000000e+00 6.3781678891e-09 1.1520000000e+00 6.4449725488e-09 1.1760000000e+00 \
 1.0506482821e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  59 6.0200000000e-09 5.0000000000e-12 1.9000000000e-10 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995501e-09 0.0000000000e+00 \
 6.0639594572e-09 2.4000000000e-02 6.1079193643e-09 4.8000000000e-02 6.1266434347e-09 7.2000000000e-02 6.1302391510e-09 9.6000000000e-02 6.1338080444e-09 1.2000000000e-01 \
 6.1424250603e-09 1.8000000000e-01 6.1511316325e-09 2.4000000000e-01 6.1599696259e-09 3.0000000000e-01 6.1689607376e-09 3.6000000000e-01 6.1781649427e-09 4.2000000000e-01 \
 6.1875295760e-09 4.8000000000e-01 6.1973663714e-09 5.4000000000e-01 6.2073069224e-09 6.0000000000e-01 6.2175403630e-09 6.6000000000e-01 6.2296995297e-09 7.2000000000e-01 \
 6.2418586965e-09 7.8000000000e-01 6.2540178632e-09 8.4000000000e-01 6.2661770299e-09 9.0000000000e-01 6.2823876978e-09 9.6000000000e-01 6.3000424812e-09 1.0200000000e+00 \
 6.3249107525e-09 1.0800000000e+00 6.3374444557e-09 1.1040000000e+00 6.3577749493e-09 1.1280000000e+00 6.3781678891e-09 1.1520000000e+00 6.4449725488e-09 1.1760000000e+00 \
 1.0506482821e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  60 6.0200000000e-09 5.0000000000e-12 1.9000000000e-10 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995501e-09 0.0000000000e+00 \
 6.0639594572e-09 2.4000000000e-02 6.1079193643e-09 4.8000000000e-02 6.1266434347e-09 7.2000000000e-02 6.1302391510e-09 9.6000000000e-02 6.1338080444e-09 1.2000000000e-01 \
 6.1424250603e-09 1.8000000000e-01 6.1511316325e-09 2.4000000000e-01 6.1599696259e-09 3.0000000000e-01 6.1689607376e-09 3.6000000000e-01 6.1781649427e-09 4.2000000000e-01 \
 6.1875295760e-09 4.8000000000e-01 6.1973663714e-09 5.4000000000e-01 6.2073069224e-09 6.0000000000e-01 6.2175403630e-09 6.6000000000e-01 6.2296995297e-09 7.2000000000e-01 \
 6.2418586965e-09 7.8000000000e-01 6.2540178632e-09 8.4000000000e-01 6.2661770299e-09 9.0000000000e-01 6.2823876978e-09 9.6000000000e-01 6.3000424812e-09 1.0200000000e+00 \
 6.3249107525e-09 1.0800000000e+00 6.3374444557e-09 1.1040000000e+00 6.3577749493e-09 1.1280000000e+00 6.3781678891e-09 1.1520000000e+00 6.4449725488e-09 1.1760000000e+00 \
 1.0506482821e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  61 6.0200000000e-09 5.0000000000e-12 1.9000000000e-10 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995501e-09 0.0000000000e+00 \
 6.0639594572e-09 2.4000000000e-02 6.1079193643e-09 4.8000000000e-02 6.1266434347e-09 7.2000000000e-02 6.1302391510e-09 9.6000000000e-02 6.1338080444e-09 1.2000000000e-01 \
 6.1424250603e-09 1.8000000000e-01 6.1511316325e-09 2.4000000000e-01 6.1599696259e-09 3.0000000000e-01 6.1689607376e-09 3.6000000000e-01 6.1781649427e-09 4.2000000000e-01 \
 6.1875295760e-09 4.8000000000e-01 6.1973663714e-09 5.4000000000e-01 6.2073069224e-09 6.0000000000e-01 6.2175403630e-09 6.6000000000e-01 6.2296995297e-09 7.2000000000e-01 \
 6.2418586965e-09 7.8000000000e-01 6.2540178632e-09 8.4000000000e-01 6.2661770299e-09 9.0000000000e-01 6.2823876978e-09 9.6000000000e-01 6.3000424812e-09 1.0200000000e+00 \
 6.3249107525e-09 1.0800000000e+00 6.3374444557e-09 1.1040000000e+00 6.3577749493e-09 1.1280000000e+00 6.3781678891e-09 1.1520000000e+00 6.4449725488e-09 1.1760000000e+00 \
 1.0506482821e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  62 6.0200000000e-09 5.0000000000e-12 1.9000000000e-10 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995501e-09 0.0000000000e+00 \
 6.0639594572e-09 2.4000000000e-02 6.1079193643e-09 4.8000000000e-02 6.1266434347e-09 7.2000000000e-02 6.1302391510e-09 9.6000000000e-02 6.1338080444e-09 1.2000000000e-01 \
 6.1424250603e-09 1.8000000000e-01 6.1511316325e-09 2.4000000000e-01 6.1599696259e-09 3.0000000000e-01 6.1689607376e-09 3.6000000000e-01 6.1781649427e-09 4.2000000000e-01 \
 6.1875295760e-09 4.8000000000e-01 6.1973663714e-09 5.4000000000e-01 6.2073069224e-09 6.0000000000e-01 6.2175403630e-09 6.6000000000e-01 6.2296995297e-09 7.2000000000e-01 \
 6.2418586965e-09 7.8000000000e-01 6.2540178632e-09 8.4000000000e-01 6.2661770299e-09 9.0000000000e-01 6.2823876978e-09 9.6000000000e-01 6.3000424812e-09 1.0200000000e+00 \
 6.3249107525e-09 1.0800000000e+00 6.3374444557e-09 1.1040000000e+00 6.3577749493e-09 1.1280000000e+00 6.3781678891e-09 1.1520000000e+00 6.4449725488e-09 1.1760000000e+00 \
 1.0506482821e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  63 6.0200000000e-09 5.0000000000e-12 1.9000000000e-10 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199995501e-09 0.0000000000e+00 \
 6.0639594572e-09 2.4000000000e-02 6.1079193643e-09 4.8000000000e-02 6.1266434347e-09 7.2000000000e-02 6.1302391510e-09 9.6000000000e-02 6.1338080444e-09 1.2000000000e-01 \
 6.1424250603e-09 1.8000000000e-01 6.1511316325e-09 2.4000000000e-01 6.1599696259e-09 3.0000000000e-01 6.1689607376e-09 3.6000000000e-01 6.1781649427e-09 4.2000000000e-01 \
 6.1875295760e-09 4.8000000000e-01 6.1973663714e-09 5.4000000000e-01 6.2073069224e-09 6.0000000000e-01 6.2175403630e-09 6.6000000000e-01 6.2296995297e-09 7.2000000000e-01 \
 6.2418586965e-09 7.8000000000e-01 6.2540178632e-09 8.4000000000e-01 6.2661770299e-09 9.0000000000e-01 6.2823876978e-09 9.6000000000e-01 6.3000424812e-09 1.0200000000e+00 \
 6.3249107525e-09 1.0800000000e+00 6.3374444557e-09 1.1040000000e+00 6.3577749493e-09 1.1280000000e+00 6.3781678891e-09 1.1520000000e+00 6.4449725488e-09 1.1760000000e+00 \
 1.0506482821e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  64 6.0200000000e-09 5.0000000000e-12 2.1000000000e-10 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994951e-09 0.0000000000e+00 \
 6.0693293976e-09 2.4000000000e-02 6.1186593002e-09 4.8000000000e-02 6.1278041333e-09 7.2000000000e-02 6.1317893499e-09 9.6000000000e-02 6.1356049837e-09 1.2000000000e-01 \
 6.1451037632e-09 1.8000000000e-01 6.1547210540e-09 2.4000000000e-01 6.1644515885e-09 3.0000000000e-01 6.1743887422e-09 3.6000000000e-01 6.1845280859e-09 4.2000000000e-01 \
 6.1950468095e-09 4.8000000000e-01 6.2056746768e-09 5.4000000000e-01 6.2168897704e-09 6.0000000000e-01 6.2288336098e-09 6.6000000000e-01 6.2407774493e-09 7.2000000000e-01 \
 6.2527212887e-09 7.8000000000e-01 6.2672783649e-09 8.4000000000e-01 6.2830405378e-09 9.0000000000e-01 6.2988027107e-09 9.6000000000e-01 6.3192667188e-09 1.0200000000e+00 \
 6.3463550438e-09 1.0800000000e+00 6.3620477522e-09 1.1040000000e+00 6.3815209788e-09 1.1280000000e+00 6.4083708614e-09 1.1520000000e+00 6.4584484985e-09 1.1760000000e+00 \
 1.0502224540e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  65 6.0200000000e-09 5.0000000000e-12 2.1000000000e-10 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994951e-09 0.0000000000e+00 \
 6.0693293976e-09 2.4000000000e-02 6.1186593002e-09 4.8000000000e-02 6.1278041333e-09 7.2000000000e-02 6.1317893499e-09 9.6000000000e-02 6.1356049837e-09 1.2000000000e-01 \
 6.1451037632e-09 1.8000000000e-01 6.1547210540e-09 2.4000000000e-01 6.1644515885e-09 3.0000000000e-01 6.1743887422e-09 3.6000000000e-01 6.1845280859e-09 4.2000000000e-01 \
 6.1950468095e-09 4.8000000000e-01 6.2056746768e-09 5.4000000000e-01 6.2168897704e-09 6.0000000000e-01 6.2288336098e-09 6.6000000000e-01 6.2407774493e-09 7.2000000000e-01 \
 6.2527212887e-09 7.8000000000e-01 6.2672783649e-09 8.4000000000e-01 6.2830405378e-09 9.0000000000e-01 6.2988027107e-09 9.6000000000e-01 6.3192667188e-09 1.0200000000e+00 \
 6.3463550438e-09 1.0800000000e+00 6.3620477522e-09 1.1040000000e+00 6.3815209788e-09 1.1280000000e+00 6.4083708614e-09 1.1520000000e+00 6.4584484985e-09 1.1760000000e+00 \
 1.0502224540e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  66 6.0200000000e-09 5.0000000000e-12 2.1000000000e-10 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994951e-09 0.0000000000e+00 \
 6.0693293976e-09 2.4000000000e-02 6.1186593002e-09 4.8000000000e-02 6.1278041333e-09 7.2000000000e-02 6.1317893499e-09 9.6000000000e-02 6.1356049837e-09 1.2000000000e-01 \
 6.1451037632e-09 1.8000000000e-01 6.1547210540e-09 2.4000000000e-01 6.1644515885e-09 3.0000000000e-01 6.1743887422e-09 3.6000000000e-01 6.1845280859e-09 4.2000000000e-01 \
 6.1950468095e-09 4.8000000000e-01 6.2056746768e-09 5.4000000000e-01 6.2168897704e-09 6.0000000000e-01 6.2288336098e-09 6.6000000000e-01 6.2407774493e-09 7.2000000000e-01 \
 6.2527212887e-09 7.8000000000e-01 6.2672783649e-09 8.4000000000e-01 6.2830405378e-09 9.0000000000e-01 6.2988027107e-09 9.6000000000e-01 6.3192667188e-09 1.0200000000e+00 \
 6.3463550438e-09 1.0800000000e+00 6.3620477522e-09 1.1040000000e+00 6.3815209788e-09 1.1280000000e+00 6.4083708614e-09 1.1520000000e+00 6.4584484985e-09 1.1760000000e+00 \
 1.0502224540e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  67 6.0200000000e-09 5.0000000000e-12 2.1000000000e-10 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994951e-09 0.0000000000e+00 \
 6.0693293976e-09 2.4000000000e-02 6.1186593002e-09 4.8000000000e-02 6.1278041333e-09 7.2000000000e-02 6.1317893499e-09 9.6000000000e-02 6.1356049837e-09 1.2000000000e-01 \
 6.1451037632e-09 1.8000000000e-01 6.1547210540e-09 2.4000000000e-01 6.1644515885e-09 3.0000000000e-01 6.1743887422e-09 3.6000000000e-01 6.1845280859e-09 4.2000000000e-01 \
 6.1950468095e-09 4.8000000000e-01 6.2056746768e-09 5.4000000000e-01 6.2168897704e-09 6.0000000000e-01 6.2288336098e-09 6.6000000000e-01 6.2407774493e-09 7.2000000000e-01 \
 6.2527212887e-09 7.8000000000e-01 6.2672783649e-09 8.4000000000e-01 6.2830405378e-09 9.0000000000e-01 6.2988027107e-09 9.6000000000e-01 6.3192667188e-09 1.0200000000e+00 \
 6.3463550438e-09 1.0800000000e+00 6.3620477522e-09 1.1040000000e+00 6.3815209788e-09 1.1280000000e+00 6.4083708614e-09 1.1520000000e+00 6.4584484985e-09 1.1760000000e+00 \
 1.0502224540e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  68 6.0200000000e-09 5.0000000000e-12 2.1000000000e-10 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994951e-09 0.0000000000e+00 \
 6.0693293976e-09 2.4000000000e-02 6.1186593002e-09 4.8000000000e-02 6.1278041333e-09 7.2000000000e-02 6.1317893499e-09 9.6000000000e-02 6.1356049837e-09 1.2000000000e-01 \
 6.1451037632e-09 1.8000000000e-01 6.1547210540e-09 2.4000000000e-01 6.1644515885e-09 3.0000000000e-01 6.1743887422e-09 3.6000000000e-01 6.1845280859e-09 4.2000000000e-01 \
 6.1950468095e-09 4.8000000000e-01 6.2056746768e-09 5.4000000000e-01 6.2168897704e-09 6.0000000000e-01 6.2288336098e-09 6.6000000000e-01 6.2407774493e-09 7.2000000000e-01 \
 6.2527212887e-09 7.8000000000e-01 6.2672783649e-09 8.4000000000e-01 6.2830405378e-09 9.0000000000e-01 6.2988027107e-09 9.6000000000e-01 6.3192667188e-09 1.0200000000e+00 \
 6.3463550438e-09 1.0800000000e+00 6.3620477522e-09 1.1040000000e+00 6.3815209788e-09 1.1280000000e+00 6.4083708614e-09 1.1520000000e+00 6.4584484985e-09 1.1760000000e+00 \
 1.0502224540e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  69 6.0200000000e-09 5.0000000000e-12 2.1000000000e-10 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994951e-09 0.0000000000e+00 \
 6.0693293976e-09 2.4000000000e-02 6.1186593002e-09 4.8000000000e-02 6.1278041333e-09 7.2000000000e-02 6.1317893499e-09 9.6000000000e-02 6.1356049837e-09 1.2000000000e-01 \
 6.1451037632e-09 1.8000000000e-01 6.1547210540e-09 2.4000000000e-01 6.1644515885e-09 3.0000000000e-01 6.1743887422e-09 3.6000000000e-01 6.1845280859e-09 4.2000000000e-01 \
 6.1950468095e-09 4.8000000000e-01 6.2056746768e-09 5.4000000000e-01 6.2168897704e-09 6.0000000000e-01 6.2288336098e-09 6.6000000000e-01 6.2407774493e-09 7.2000000000e-01 \
 6.2527212887e-09 7.8000000000e-01 6.2672783649e-09 8.4000000000e-01 6.2830405378e-09 9.0000000000e-01 6.2988027107e-09 9.6000000000e-01 6.3192667188e-09 1.0200000000e+00 \
 6.3463550438e-09 1.0800000000e+00 6.3620477522e-09 1.1040000000e+00 6.3815209788e-09 1.1280000000e+00 6.4083708614e-09 1.1520000000e+00 6.4584484985e-09 1.1760000000e+00 \
 1.0502224540e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  70 6.0200000000e-09 5.0000000000e-12 2.1000000000e-10 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994951e-09 0.0000000000e+00 \
 6.0693293976e-09 2.4000000000e-02 6.1186593002e-09 4.8000000000e-02 6.1278041333e-09 7.2000000000e-02 6.1317893499e-09 9.6000000000e-02 6.1356049837e-09 1.2000000000e-01 \
 6.1451037632e-09 1.8000000000e-01 6.1547210540e-09 2.4000000000e-01 6.1644515885e-09 3.0000000000e-01 6.1743887422e-09 3.6000000000e-01 6.1845280859e-09 4.2000000000e-01 \
 6.1950468095e-09 4.8000000000e-01 6.2056746768e-09 5.4000000000e-01 6.2168897704e-09 6.0000000000e-01 6.2288336098e-09 6.6000000000e-01 6.2407774493e-09 7.2000000000e-01 \
 6.2527212887e-09 7.8000000000e-01 6.2672783649e-09 8.4000000000e-01 6.2830405378e-09 9.0000000000e-01 6.2988027107e-09 9.6000000000e-01 6.3192667188e-09 1.0200000000e+00 \
 6.3463550438e-09 1.0800000000e+00 6.3620477522e-09 1.1040000000e+00 6.3815209788e-09 1.1280000000e+00 6.4083708614e-09 1.1520000000e+00 6.4584484985e-09 1.1760000000e+00 \
 1.0502224540e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  71 6.0200000000e-09 5.0000000000e-12 2.1000000000e-10 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994951e-09 0.0000000000e+00 \
 6.0693293976e-09 2.4000000000e-02 6.1186593002e-09 4.8000000000e-02 6.1278041333e-09 7.2000000000e-02 6.1317893499e-09 9.6000000000e-02 6.1356049837e-09 1.2000000000e-01 \
 6.1451037632e-09 1.8000000000e-01 6.1547210540e-09 2.4000000000e-01 6.1644515885e-09 3.0000000000e-01 6.1743887422e-09 3.6000000000e-01 6.1845280859e-09 4.2000000000e-01 \
 6.1950468095e-09 4.8000000000e-01 6.2056746768e-09 5.4000000000e-01 6.2168897704e-09 6.0000000000e-01 6.2288336098e-09 6.6000000000e-01 6.2407774493e-09 7.2000000000e-01 \
 6.2527212887e-09 7.8000000000e-01 6.2672783649e-09 8.4000000000e-01 6.2830405378e-09 9.0000000000e-01 6.2988027107e-09 9.6000000000e-01 6.3192667188e-09 1.0200000000e+00 \
 6.3463550438e-09 1.0800000000e+00 6.3620477522e-09 1.1040000000e+00 6.3815209788e-09 1.1280000000e+00 6.4083708614e-09 1.1520000000e+00 6.4584484985e-09 1.1760000000e+00 \
 1.0502224540e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  72 6.0200000000e-09 5.0000000000e-12 2.5000000000e-10 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993834e-09 0.0000000000e+00 \
 6.0802456882e-09 2.4000000000e-02 6.1253654930e-09 4.8000000000e-02 6.1300900602e-09 7.2000000000e-02 6.1347167298e-09 9.6000000000e-02 6.1392060446e-09 1.2000000000e-01 \
 6.1504718704e-09 1.8000000000e-01 6.1618947797e-09 2.4000000000e-01 6.1734833379e-09 3.0000000000e-01 6.1853307748e-09 3.6000000000e-01 6.1973962018e-09 4.2000000000e-01 \
 6.2099835246e-09 4.8000000000e-01 6.2225708474e-09 5.4000000000e-01 6.2359801305e-09 6.0000000000e-01 6.2501674295e-09 6.6000000000e-01 6.2643547285e-09 7.2000000000e-01 \
 6.2785420275e-09 7.8000000000e-01 6.2961170536e-09 8.4000000000e-01 6.3149265596e-09 9.0000000000e-01 6.3337360655e-09 9.6000000000e-01 6.3578017394e-09 1.0200000000e+00 \
 6.3900256237e-09 1.0800000000e+00 6.4086815242e-09 1.1040000000e+00 6.4314892451e-09 1.1280000000e+00 6.4652476644e-09 1.1520000000e+00 6.5227899873e-09 1.1760000000e+00 \
 1.0502342926e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  73 6.0200000000e-09 5.0000000000e-12 2.5000000000e-10 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993834e-09 0.0000000000e+00 \
 6.0802456882e-09 2.4000000000e-02 6.1253654930e-09 4.8000000000e-02 6.1300900602e-09 7.2000000000e-02 6.1347167298e-09 9.6000000000e-02 6.1392060446e-09 1.2000000000e-01 \
 6.1504718704e-09 1.8000000000e-01 6.1618947797e-09 2.4000000000e-01 6.1734833379e-09 3.0000000000e-01 6.1853307748e-09 3.6000000000e-01 6.1973962018e-09 4.2000000000e-01 \
 6.2099835246e-09 4.8000000000e-01 6.2225708474e-09 5.4000000000e-01 6.2359801305e-09 6.0000000000e-01 6.2501674295e-09 6.6000000000e-01 6.2643547285e-09 7.2000000000e-01 \
 6.2785420275e-09 7.8000000000e-01 6.2961170536e-09 8.4000000000e-01 6.3149265596e-09 9.0000000000e-01 6.3337360655e-09 9.6000000000e-01 6.3578017394e-09 1.0200000000e+00 \
 6.3900256237e-09 1.0800000000e+00 6.4086815242e-09 1.1040000000e+00 6.4314892451e-09 1.1280000000e+00 6.4652476644e-09 1.1520000000e+00 6.5227899873e-09 1.1760000000e+00 \
 1.0502342926e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  74 6.0200000000e-09 5.0000000000e-12 2.5000000000e-10 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993834e-09 0.0000000000e+00 \
 6.0802456882e-09 2.4000000000e-02 6.1253654930e-09 4.8000000000e-02 6.1300900602e-09 7.2000000000e-02 6.1347167298e-09 9.6000000000e-02 6.1392060446e-09 1.2000000000e-01 \
 6.1504718704e-09 1.8000000000e-01 6.1618947797e-09 2.4000000000e-01 6.1734833379e-09 3.0000000000e-01 6.1853307748e-09 3.6000000000e-01 6.1973962018e-09 4.2000000000e-01 \
 6.2099835246e-09 4.8000000000e-01 6.2225708474e-09 5.4000000000e-01 6.2359801305e-09 6.0000000000e-01 6.2501674295e-09 6.6000000000e-01 6.2643547285e-09 7.2000000000e-01 \
 6.2785420275e-09 7.8000000000e-01 6.2961170536e-09 8.4000000000e-01 6.3149265596e-09 9.0000000000e-01 6.3337360655e-09 9.6000000000e-01 6.3578017394e-09 1.0200000000e+00 \
 6.3900256237e-09 1.0800000000e+00 6.4086815242e-09 1.1040000000e+00 6.4314892451e-09 1.1280000000e+00 6.4652476644e-09 1.1520000000e+00 6.5227899873e-09 1.1760000000e+00 \
 1.0502342926e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  75 6.0200000000e-09 5.0000000000e-12 2.5000000000e-10 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993834e-09 0.0000000000e+00 \
 6.0802456882e-09 2.4000000000e-02 6.1253654930e-09 4.8000000000e-02 6.1300900602e-09 7.2000000000e-02 6.1347167298e-09 9.6000000000e-02 6.1392060446e-09 1.2000000000e-01 \
 6.1504718704e-09 1.8000000000e-01 6.1618947797e-09 2.4000000000e-01 6.1734833379e-09 3.0000000000e-01 6.1853307748e-09 3.6000000000e-01 6.1973962018e-09 4.2000000000e-01 \
 6.2099835246e-09 4.8000000000e-01 6.2225708474e-09 5.4000000000e-01 6.2359801305e-09 6.0000000000e-01 6.2501674295e-09 6.6000000000e-01 6.2643547285e-09 7.2000000000e-01 \
 6.2785420275e-09 7.8000000000e-01 6.2961170536e-09 8.4000000000e-01 6.3149265596e-09 9.0000000000e-01 6.3337360655e-09 9.6000000000e-01 6.3578017394e-09 1.0200000000e+00 \
 6.3900256237e-09 1.0800000000e+00 6.4086815242e-09 1.1040000000e+00 6.4314892451e-09 1.1280000000e+00 6.4652476644e-09 1.1520000000e+00 6.5227899873e-09 1.1760000000e+00 \
 1.0502342926e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  76 6.0200000000e-09 5.0000000000e-12 2.5000000000e-10 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993834e-09 0.0000000000e+00 \
 6.0802456882e-09 2.4000000000e-02 6.1253654930e-09 4.8000000000e-02 6.1300900602e-09 7.2000000000e-02 6.1347167298e-09 9.6000000000e-02 6.1392060446e-09 1.2000000000e-01 \
 6.1504718704e-09 1.8000000000e-01 6.1618947797e-09 2.4000000000e-01 6.1734833379e-09 3.0000000000e-01 6.1853307748e-09 3.6000000000e-01 6.1973962018e-09 4.2000000000e-01 \
 6.2099835246e-09 4.8000000000e-01 6.2225708474e-09 5.4000000000e-01 6.2359801305e-09 6.0000000000e-01 6.2501674295e-09 6.6000000000e-01 6.2643547285e-09 7.2000000000e-01 \
 6.2785420275e-09 7.8000000000e-01 6.2961170536e-09 8.4000000000e-01 6.3149265596e-09 9.0000000000e-01 6.3337360655e-09 9.6000000000e-01 6.3578017394e-09 1.0200000000e+00 \
 6.3900256237e-09 1.0800000000e+00 6.4086815242e-09 1.1040000000e+00 6.4314892451e-09 1.1280000000e+00 6.4652476644e-09 1.1520000000e+00 6.5227899873e-09 1.1760000000e+00 \
 1.0502342926e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  77 6.0200000000e-09 5.0000000000e-12 2.5000000000e-10 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993834e-09 0.0000000000e+00 \
 6.0802456882e-09 2.4000000000e-02 6.1253654930e-09 4.8000000000e-02 6.1300900602e-09 7.2000000000e-02 6.1347167298e-09 9.6000000000e-02 6.1392060446e-09 1.2000000000e-01 \
 6.1504718704e-09 1.8000000000e-01 6.1618947797e-09 2.4000000000e-01 6.1734833379e-09 3.0000000000e-01 6.1853307748e-09 3.6000000000e-01 6.1973962018e-09 4.2000000000e-01 \
 6.2099835246e-09 4.8000000000e-01 6.2225708474e-09 5.4000000000e-01 6.2359801305e-09 6.0000000000e-01 6.2501674295e-09 6.6000000000e-01 6.2643547285e-09 7.2000000000e-01 \
 6.2785420275e-09 7.8000000000e-01 6.2961170536e-09 8.4000000000e-01 6.3149265596e-09 9.0000000000e-01 6.3337360655e-09 9.6000000000e-01 6.3578017394e-09 1.0200000000e+00 \
 6.3900256237e-09 1.0800000000e+00 6.4086815242e-09 1.1040000000e+00 6.4314892451e-09 1.1280000000e+00 6.4652476644e-09 1.1520000000e+00 6.5227899873e-09 1.1760000000e+00 \
 1.0502342926e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  78 6.0200000000e-09 5.0000000000e-12 2.5000000000e-10 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993834e-09 0.0000000000e+00 \
 6.0802456882e-09 2.4000000000e-02 6.1253654930e-09 4.8000000000e-02 6.1300900602e-09 7.2000000000e-02 6.1347167298e-09 9.6000000000e-02 6.1392060446e-09 1.2000000000e-01 \
 6.1504718704e-09 1.8000000000e-01 6.1618947797e-09 2.4000000000e-01 6.1734833379e-09 3.0000000000e-01 6.1853307748e-09 3.6000000000e-01 6.1973962018e-09 4.2000000000e-01 \
 6.2099835246e-09 4.8000000000e-01 6.2225708474e-09 5.4000000000e-01 6.2359801305e-09 6.0000000000e-01 6.2501674295e-09 6.6000000000e-01 6.2643547285e-09 7.2000000000e-01 \
 6.2785420275e-09 7.8000000000e-01 6.2961170536e-09 8.4000000000e-01 6.3149265596e-09 9.0000000000e-01 6.3337360655e-09 9.6000000000e-01 6.3578017394e-09 1.0200000000e+00 \
 6.3900256237e-09 1.0800000000e+00 6.4086815242e-09 1.1040000000e+00 6.4314892451e-09 1.1280000000e+00 6.4652476644e-09 1.1520000000e+00 6.5227899873e-09 1.1760000000e+00 \
 1.0502342926e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  79 6.0200000000e-09 5.0000000000e-12 2.5000000000e-10 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993834e-09 0.0000000000e+00 \
 6.0802456882e-09 2.4000000000e-02 6.1253654930e-09 4.8000000000e-02 6.1300900602e-09 7.2000000000e-02 6.1347167298e-09 9.6000000000e-02 6.1392060446e-09 1.2000000000e-01 \
 6.1504718704e-09 1.8000000000e-01 6.1618947797e-09 2.4000000000e-01 6.1734833379e-09 3.0000000000e-01 6.1853307748e-09 3.6000000000e-01 6.1973962018e-09 4.2000000000e-01 \
 6.2099835246e-09 4.8000000000e-01 6.2225708474e-09 5.4000000000e-01 6.2359801305e-09 6.0000000000e-01 6.2501674295e-09 6.6000000000e-01 6.2643547285e-09 7.2000000000e-01 \
 6.2785420275e-09 7.8000000000e-01 6.2961170536e-09 8.4000000000e-01 6.3149265596e-09 9.0000000000e-01 6.3337360655e-09 9.6000000000e-01 6.3578017394e-09 1.0200000000e+00 \
 6.3900256237e-09 1.0800000000e+00 6.4086815242e-09 1.1040000000e+00 6.4314892451e-09 1.1280000000e+00 6.4652476644e-09 1.1520000000e+00 6.5227899873e-09 1.1760000000e+00 \
 1.0502342926e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  80 6.0200000000e-09 5.0000000000e-12 3.0000000000e-10 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994666e-09 0.0000000000e+00 \
 6.0721183495e-09 2.4000000000e-02 6.1242372324e-09 4.8000000000e-02 6.1328857049e-09 7.2000000000e-02 6.1383110536e-09 9.6000000000e-02 6.1436699680e-09 1.2000000000e-01 \
 6.1571508552e-09 1.8000000000e-01 6.1707908387e-09 2.4000000000e-01 6.1847019084e-09 3.0000000000e-01 6.1989260240e-09 3.6000000000e-01 6.2136181341e-09 4.2000000000e-01 \
 6.2286018609e-09 4.8000000000e-01 6.2435855877e-09 5.4000000000e-01 6.2599911652e-09 6.0000000000e-01 6.2768877379e-09 6.6000000000e-01 6.2937843106e-09 7.2000000000e-01 \
 6.3106808833e-09 7.8000000000e-01 6.3324180220e-09 8.4000000000e-01 6.3549264358e-09 9.0000000000e-01 6.3774348495e-09 9.6000000000e-01 6.4060076594e-09 1.0200000000e+00 \
 6.4446809656e-09 1.0800000000e+00 6.4670335360e-09 1.1040000000e+00 6.4941575522e-09 1.1280000000e+00 6.5357531085e-09 1.1520000000e+00 6.6036375480e-09 1.1760000000e+00 \
 1.0502170330e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  81 6.0200000000e-09 5.0000000000e-12 3.0000000000e-10 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994666e-09 0.0000000000e+00 \
 6.0721183495e-09 2.4000000000e-02 6.1242372324e-09 4.8000000000e-02 6.1328857049e-09 7.2000000000e-02 6.1383110536e-09 9.6000000000e-02 6.1436699680e-09 1.2000000000e-01 \
 6.1571508552e-09 1.8000000000e-01 6.1707908387e-09 2.4000000000e-01 6.1847019084e-09 3.0000000000e-01 6.1989260240e-09 3.6000000000e-01 6.2136181341e-09 4.2000000000e-01 \
 6.2286018609e-09 4.8000000000e-01 6.2435855877e-09 5.4000000000e-01 6.2599911652e-09 6.0000000000e-01 6.2768877379e-09 6.6000000000e-01 6.2937843106e-09 7.2000000000e-01 \
 6.3106808833e-09 7.8000000000e-01 6.3324180220e-09 8.4000000000e-01 6.3549264358e-09 9.0000000000e-01 6.3774348495e-09 9.6000000000e-01 6.4060076594e-09 1.0200000000e+00 \
 6.4446809656e-09 1.0800000000e+00 6.4670335360e-09 1.1040000000e+00 6.4941575522e-09 1.1280000000e+00 6.5357531085e-09 1.1520000000e+00 6.6036375480e-09 1.1760000000e+00 \
 1.0502170330e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  82 6.0200000000e-09 5.0000000000e-12 3.0000000000e-10 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994666e-09 0.0000000000e+00 \
 6.0721183495e-09 2.4000000000e-02 6.1242372324e-09 4.8000000000e-02 6.1328857049e-09 7.2000000000e-02 6.1383110536e-09 9.6000000000e-02 6.1436699680e-09 1.2000000000e-01 \
 6.1571508552e-09 1.8000000000e-01 6.1707908387e-09 2.4000000000e-01 6.1847019084e-09 3.0000000000e-01 6.1989260240e-09 3.6000000000e-01 6.2136181341e-09 4.2000000000e-01 \
 6.2286018609e-09 4.8000000000e-01 6.2435855877e-09 5.4000000000e-01 6.2599911652e-09 6.0000000000e-01 6.2768877379e-09 6.6000000000e-01 6.2937843106e-09 7.2000000000e-01 \
 6.3106808833e-09 7.8000000000e-01 6.3324180220e-09 8.4000000000e-01 6.3549264358e-09 9.0000000000e-01 6.3774348495e-09 9.6000000000e-01 6.4060076594e-09 1.0200000000e+00 \
 6.4446809656e-09 1.0800000000e+00 6.4670335360e-09 1.1040000000e+00 6.4941575522e-09 1.1280000000e+00 6.5357531085e-09 1.1520000000e+00 6.6036375480e-09 1.1760000000e+00 \
 1.0502170330e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  83 6.0200000000e-09 5.0000000000e-12 3.0000000000e-10 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994666e-09 0.0000000000e+00 \
 6.0721183495e-09 2.4000000000e-02 6.1242372324e-09 4.8000000000e-02 6.1328857049e-09 7.2000000000e-02 6.1383110536e-09 9.6000000000e-02 6.1436699680e-09 1.2000000000e-01 \
 6.1571508552e-09 1.8000000000e-01 6.1707908387e-09 2.4000000000e-01 6.1847019084e-09 3.0000000000e-01 6.1989260240e-09 3.6000000000e-01 6.2136181341e-09 4.2000000000e-01 \
 6.2286018609e-09 4.8000000000e-01 6.2435855877e-09 5.4000000000e-01 6.2599911652e-09 6.0000000000e-01 6.2768877379e-09 6.6000000000e-01 6.2937843106e-09 7.2000000000e-01 \
 6.3106808833e-09 7.8000000000e-01 6.3324180220e-09 8.4000000000e-01 6.3549264358e-09 9.0000000000e-01 6.3774348495e-09 9.6000000000e-01 6.4060076594e-09 1.0200000000e+00 \
 6.4446809656e-09 1.0800000000e+00 6.4670335360e-09 1.1040000000e+00 6.4941575522e-09 1.1280000000e+00 6.5357531085e-09 1.1520000000e+00 6.6036375480e-09 1.1760000000e+00 \
 1.0502170330e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  84 6.0200000000e-09 5.0000000000e-12 3.0000000000e-10 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994666e-09 0.0000000000e+00 \
 6.0721183495e-09 2.4000000000e-02 6.1242372324e-09 4.8000000000e-02 6.1328857049e-09 7.2000000000e-02 6.1383110536e-09 9.6000000000e-02 6.1436699680e-09 1.2000000000e-01 \
 6.1571508552e-09 1.8000000000e-01 6.1707908387e-09 2.4000000000e-01 6.1847019084e-09 3.0000000000e-01 6.1989260240e-09 3.6000000000e-01 6.2136181341e-09 4.2000000000e-01 \
 6.2286018609e-09 4.8000000000e-01 6.2435855877e-09 5.4000000000e-01 6.2599911652e-09 6.0000000000e-01 6.2768877379e-09 6.6000000000e-01 6.2937843106e-09 7.2000000000e-01 \
 6.3106808833e-09 7.8000000000e-01 6.3324180220e-09 8.4000000000e-01 6.3549264358e-09 9.0000000000e-01 6.3774348495e-09 9.6000000000e-01 6.4060076594e-09 1.0200000000e+00 \
 6.4446809656e-09 1.0800000000e+00 6.4670335360e-09 1.1040000000e+00 6.4941575522e-09 1.1280000000e+00 6.5357531085e-09 1.1520000000e+00 6.6036375480e-09 1.1760000000e+00 \
 1.0502170330e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  85 6.0200000000e-09 5.0000000000e-12 3.0000000000e-10 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994666e-09 0.0000000000e+00 \
 6.0721183495e-09 2.4000000000e-02 6.1242372324e-09 4.8000000000e-02 6.1328857049e-09 7.2000000000e-02 6.1383110536e-09 9.6000000000e-02 6.1436699680e-09 1.2000000000e-01 \
 6.1571508552e-09 1.8000000000e-01 6.1707908387e-09 2.4000000000e-01 6.1847019084e-09 3.0000000000e-01 6.1989260240e-09 3.6000000000e-01 6.2136181341e-09 4.2000000000e-01 \
 6.2286018609e-09 4.8000000000e-01 6.2435855877e-09 5.4000000000e-01 6.2599911652e-09 6.0000000000e-01 6.2768877379e-09 6.6000000000e-01 6.2937843106e-09 7.2000000000e-01 \
 6.3106808833e-09 7.8000000000e-01 6.3324180220e-09 8.4000000000e-01 6.3549264358e-09 9.0000000000e-01 6.3774348495e-09 9.6000000000e-01 6.4060076594e-09 1.0200000000e+00 \
 6.4446809656e-09 1.0800000000e+00 6.4670335360e-09 1.1040000000e+00 6.4941575522e-09 1.1280000000e+00 6.5357531085e-09 1.1520000000e+00 6.6036375480e-09 1.1760000000e+00 \
 1.0502170330e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  86 6.0200000000e-09 5.0000000000e-12 3.0000000000e-10 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994666e-09 0.0000000000e+00 \
 6.0721183495e-09 2.4000000000e-02 6.1242372324e-09 4.8000000000e-02 6.1328857049e-09 7.2000000000e-02 6.1383110536e-09 9.6000000000e-02 6.1436699680e-09 1.2000000000e-01 \
 6.1571508552e-09 1.8000000000e-01 6.1707908387e-09 2.4000000000e-01 6.1847019084e-09 3.0000000000e-01 6.1989260240e-09 3.6000000000e-01 6.2136181341e-09 4.2000000000e-01 \
 6.2286018609e-09 4.8000000000e-01 6.2435855877e-09 5.4000000000e-01 6.2599911652e-09 6.0000000000e-01 6.2768877379e-09 6.6000000000e-01 6.2937843106e-09 7.2000000000e-01 \
 6.3106808833e-09 7.8000000000e-01 6.3324180220e-09 8.4000000000e-01 6.3549264358e-09 9.0000000000e-01 6.3774348495e-09 9.6000000000e-01 6.4060076594e-09 1.0200000000e+00 \
 6.4446809656e-09 1.0800000000e+00 6.4670335360e-09 1.1040000000e+00 6.4941575522e-09 1.1280000000e+00 6.5357531085e-09 1.1520000000e+00 6.6036375480e-09 1.1760000000e+00 \
 1.0502170330e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  87 6.0200000000e-09 5.0000000000e-12 3.0000000000e-10 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199994666e-09 0.0000000000e+00 \
 6.0721183495e-09 2.4000000000e-02 6.1242372324e-09 4.8000000000e-02 6.1328857049e-09 7.2000000000e-02 6.1383110536e-09 9.6000000000e-02 6.1436699680e-09 1.2000000000e-01 \
 6.1571508552e-09 1.8000000000e-01 6.1707908387e-09 2.4000000000e-01 6.1847019084e-09 3.0000000000e-01 6.1989260240e-09 3.6000000000e-01 6.2136181341e-09 4.2000000000e-01 \
 6.2286018609e-09 4.8000000000e-01 6.2435855877e-09 5.4000000000e-01 6.2599911652e-09 6.0000000000e-01 6.2768877379e-09 6.6000000000e-01 6.2937843106e-09 7.2000000000e-01 \
 6.3106808833e-09 7.8000000000e-01 6.3324180220e-09 8.4000000000e-01 6.3549264358e-09 9.0000000000e-01 6.3774348495e-09 9.6000000000e-01 6.4060076594e-09 1.0200000000e+00 \
 6.4446809656e-09 1.0800000000e+00 6.4670335360e-09 1.1040000000e+00 6.4941575522e-09 1.1280000000e+00 6.5357531085e-09 1.1520000000e+00 6.6036375480e-09 1.1760000000e+00 \
 1.0502170330e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  88 6.0200000000e-09 5.0000000000e-12 5.0000000000e-10 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993319e-09 0.0000000000e+00 \
 6.0852774969e-09 2.4000000000e-02 6.1347347546e-09 4.8000000000e-02 6.1435742085e-09 7.2000000000e-02 6.1524153749e-09 9.6000000000e-02 6.1612603664e-09 1.2000000000e-01 \
 6.1835872642e-09 1.8000000000e-01 6.2063678017e-09 2.4000000000e-01 6.2296475431e-09 3.0000000000e-01 6.2534731619e-09 3.6000000000e-01 6.2772987807e-09 4.2000000000e-01 \
 6.3032918463e-09 4.8000000000e-01 6.3294983814e-09 5.4000000000e-01 6.3557049165e-09 6.0000000000e-01 6.3819114517e-09 6.6000000000e-01 6.4098652143e-09 7.2000000000e-01 \
 6.4408423347e-09 7.8000000000e-01 6.4718194552e-09 8.4000000000e-01 6.5104733884e-09 9.0000000000e-01 6.5529166502e-09 9.6000000000e-01 6.5953599120e-09 1.0200000000e+00 \
 6.6632019326e-09 1.0800000000e+00 6.6967301692e-09 1.1040000000e+00 6.7495079307e-09 1.1280000000e+00 6.8133336166e-09 1.1520000000e+00 2.7558635555e-08 1.1760000000e+00 \
 1.0501493087e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  89 6.0200000000e-09 5.0000000000e-12 5.0000000000e-10 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993319e-09 0.0000000000e+00 \
 6.0852774969e-09 2.4000000000e-02 6.1347347546e-09 4.8000000000e-02 6.1435742085e-09 7.2000000000e-02 6.1524153749e-09 9.6000000000e-02 6.1612603664e-09 1.2000000000e-01 \
 6.1835872642e-09 1.8000000000e-01 6.2063678017e-09 2.4000000000e-01 6.2296475431e-09 3.0000000000e-01 6.2534731619e-09 3.6000000000e-01 6.2772987807e-09 4.2000000000e-01 \
 6.3032918463e-09 4.8000000000e-01 6.3294983814e-09 5.4000000000e-01 6.3557049165e-09 6.0000000000e-01 6.3819114517e-09 6.6000000000e-01 6.4098652143e-09 7.2000000000e-01 \
 6.4408423347e-09 7.8000000000e-01 6.4718194552e-09 8.4000000000e-01 6.5104733884e-09 9.0000000000e-01 6.5529166502e-09 9.6000000000e-01 6.5953599120e-09 1.0200000000e+00 \
 6.6632019326e-09 1.0800000000e+00 6.6967301692e-09 1.1040000000e+00 6.7495079307e-09 1.1280000000e+00 6.8133336166e-09 1.1520000000e+00 2.7558635555e-08 1.1760000000e+00 \
 1.0501493087e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  90 6.0200000000e-09 5.0000000000e-12 5.0000000000e-10 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993319e-09 0.0000000000e+00 \
 6.0852774969e-09 2.4000000000e-02 6.1347347546e-09 4.8000000000e-02 6.1435742085e-09 7.2000000000e-02 6.1524153749e-09 9.6000000000e-02 6.1612603664e-09 1.2000000000e-01 \
 6.1835872642e-09 1.8000000000e-01 6.2063678017e-09 2.4000000000e-01 6.2296475431e-09 3.0000000000e-01 6.2534731619e-09 3.6000000000e-01 6.2772987807e-09 4.2000000000e-01 \
 6.3032918463e-09 4.8000000000e-01 6.3294983814e-09 5.4000000000e-01 6.3557049165e-09 6.0000000000e-01 6.3819114517e-09 6.6000000000e-01 6.4098652143e-09 7.2000000000e-01 \
 6.4408423347e-09 7.8000000000e-01 6.4718194552e-09 8.4000000000e-01 6.5104733884e-09 9.0000000000e-01 6.5529166502e-09 9.6000000000e-01 6.5953599120e-09 1.0200000000e+00 \
 6.6632019326e-09 1.0800000000e+00 6.6967301692e-09 1.1040000000e+00 6.7495079307e-09 1.1280000000e+00 6.8133336166e-09 1.1520000000e+00 2.7558635555e-08 1.1760000000e+00 \
 1.0501493087e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  91 6.0200000000e-09 5.0000000000e-12 5.0000000000e-10 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993319e-09 0.0000000000e+00 \
 6.0852774969e-09 2.4000000000e-02 6.1347347546e-09 4.8000000000e-02 6.1435742085e-09 7.2000000000e-02 6.1524153749e-09 9.6000000000e-02 6.1612603664e-09 1.2000000000e-01 \
 6.1835872642e-09 1.8000000000e-01 6.2063678017e-09 2.4000000000e-01 6.2296475431e-09 3.0000000000e-01 6.2534731619e-09 3.6000000000e-01 6.2772987807e-09 4.2000000000e-01 \
 6.3032918463e-09 4.8000000000e-01 6.3294983814e-09 5.4000000000e-01 6.3557049165e-09 6.0000000000e-01 6.3819114517e-09 6.6000000000e-01 6.4098652143e-09 7.2000000000e-01 \
 6.4408423347e-09 7.8000000000e-01 6.4718194552e-09 8.4000000000e-01 6.5104733884e-09 9.0000000000e-01 6.5529166502e-09 9.6000000000e-01 6.5953599120e-09 1.0200000000e+00 \
 6.6632019326e-09 1.0800000000e+00 6.6967301692e-09 1.1040000000e+00 6.7495079307e-09 1.1280000000e+00 6.8133336166e-09 1.1520000000e+00 2.7558635555e-08 1.1760000000e+00 \
 1.0501493087e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  92 6.0200000000e-09 5.0000000000e-12 5.0000000000e-10 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993319e-09 0.0000000000e+00 \
 6.0852774969e-09 2.4000000000e-02 6.1347347546e-09 4.8000000000e-02 6.1435742085e-09 7.2000000000e-02 6.1524153749e-09 9.6000000000e-02 6.1612603664e-09 1.2000000000e-01 \
 6.1835872642e-09 1.8000000000e-01 6.2063678017e-09 2.4000000000e-01 6.2296475431e-09 3.0000000000e-01 6.2534731619e-09 3.6000000000e-01 6.2772987807e-09 4.2000000000e-01 \
 6.3032918463e-09 4.8000000000e-01 6.3294983814e-09 5.4000000000e-01 6.3557049165e-09 6.0000000000e-01 6.3819114517e-09 6.6000000000e-01 6.4098652143e-09 7.2000000000e-01 \
 6.4408423347e-09 7.8000000000e-01 6.4718194552e-09 8.4000000000e-01 6.5104733884e-09 9.0000000000e-01 6.5529166502e-09 9.6000000000e-01 6.5953599120e-09 1.0200000000e+00 \
 6.6632019326e-09 1.0800000000e+00 6.6967301692e-09 1.1040000000e+00 6.7495079307e-09 1.1280000000e+00 6.8133336166e-09 1.1520000000e+00 2.7558635555e-08 1.1760000000e+00 \
 1.0501493087e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  93 6.0200000000e-09 5.0000000000e-12 5.0000000000e-10 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993319e-09 0.0000000000e+00 \
 6.0852774969e-09 2.4000000000e-02 6.1347347546e-09 4.8000000000e-02 6.1435742085e-09 7.2000000000e-02 6.1524153749e-09 9.6000000000e-02 6.1612603664e-09 1.2000000000e-01 \
 6.1835872642e-09 1.8000000000e-01 6.2063678017e-09 2.4000000000e-01 6.2296475431e-09 3.0000000000e-01 6.2534731619e-09 3.6000000000e-01 6.2772987807e-09 4.2000000000e-01 \
 6.3032918463e-09 4.8000000000e-01 6.3294983814e-09 5.4000000000e-01 6.3557049165e-09 6.0000000000e-01 6.3819114517e-09 6.6000000000e-01 6.4098652143e-09 7.2000000000e-01 \
 6.4408423347e-09 7.8000000000e-01 6.4718194552e-09 8.4000000000e-01 6.5104733884e-09 9.0000000000e-01 6.5529166502e-09 9.6000000000e-01 6.5953599120e-09 1.0200000000e+00 \
 6.6632019326e-09 1.0800000000e+00 6.6967301692e-09 1.1040000000e+00 6.7495079307e-09 1.1280000000e+00 6.8133336166e-09 1.1520000000e+00 2.7558635555e-08 1.1760000000e+00 \
 1.0501493087e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  94 6.0200000000e-09 5.0000000000e-12 5.0000000000e-10 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993319e-09 0.0000000000e+00 \
 6.0852774969e-09 2.4000000000e-02 6.1347347546e-09 4.8000000000e-02 6.1435742085e-09 7.2000000000e-02 6.1524153749e-09 9.6000000000e-02 6.1612603664e-09 1.2000000000e-01 \
 6.1835872642e-09 1.8000000000e-01 6.2063678017e-09 2.4000000000e-01 6.2296475431e-09 3.0000000000e-01 6.2534731619e-09 3.6000000000e-01 6.2772987807e-09 4.2000000000e-01 \
 6.3032918463e-09 4.8000000000e-01 6.3294983814e-09 5.4000000000e-01 6.3557049165e-09 6.0000000000e-01 6.3819114517e-09 6.6000000000e-01 6.4098652143e-09 7.2000000000e-01 \
 6.4408423347e-09 7.8000000000e-01 6.4718194552e-09 8.4000000000e-01 6.5104733884e-09 9.0000000000e-01 6.5529166502e-09 9.6000000000e-01 6.5953599120e-09 1.0200000000e+00 \
 6.6632019326e-09 1.0800000000e+00 6.6967301692e-09 1.1040000000e+00 6.7495079307e-09 1.1280000000e+00 6.8133336166e-09 1.1520000000e+00 2.7558635555e-08 1.1760000000e+00 \
 1.0501493087e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  95 6.0200000000e-09 5.0000000000e-12 5.0000000000e-10 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199993319e-09 0.0000000000e+00 \
 6.0852774969e-09 2.4000000000e-02 6.1347347546e-09 4.8000000000e-02 6.1435742085e-09 7.2000000000e-02 6.1524153749e-09 9.6000000000e-02 6.1612603664e-09 1.2000000000e-01 \
 6.1835872642e-09 1.8000000000e-01 6.2063678017e-09 2.4000000000e-01 6.2296475431e-09 3.0000000000e-01 6.2534731619e-09 3.6000000000e-01 6.2772987807e-09 4.2000000000e-01 \
 6.3032918463e-09 4.8000000000e-01 6.3294983814e-09 5.4000000000e-01 6.3557049165e-09 6.0000000000e-01 6.3819114517e-09 6.6000000000e-01 6.4098652143e-09 7.2000000000e-01 \
 6.4408423347e-09 7.8000000000e-01 6.4718194552e-09 8.4000000000e-01 6.5104733884e-09 9.0000000000e-01 6.5529166502e-09 9.6000000000e-01 6.5953599120e-09 1.0200000000e+00 \
 6.6632019326e-09 1.0800000000e+00 6.6967301692e-09 1.1040000000e+00 6.7495079307e-09 1.1280000000e+00 6.8133336166e-09 1.1520000000e+00 2.7558635555e-08 1.1760000000e+00 \
 1.0501493087e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  96 6.0200000000e-09 5.0000000000e-12 7.0000000000e-10 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199992347e-09 0.0000000000e+00 \
 6.0947788167e-09 2.4000000000e-02 6.1418332530e-09 4.8000000000e-02 6.1541385209e-09 7.2000000000e-02 6.1664659784e-09 9.6000000000e-02 6.1787996980e-09 1.2000000000e-01 \
 6.2102593665e-09 1.8000000000e-01 6.2421058126e-09 2.4000000000e-01 6.2747382279e-09 3.0000000000e-01 6.3078137450e-09 3.6000000000e-01 6.3428629840e-09 4.2000000000e-01 \
 6.3779122229e-09 4.8000000000e-01 6.4129614619e-09 5.4000000000e-01 6.4489724455e-09 6.0000000000e-01 6.4891617349e-09 6.6000000000e-01 6.5293510243e-09 7.2000000000e-01 \
 6.5695403137e-09 7.8000000000e-01 6.6183659593e-09 8.4000000000e-01 6.6726399940e-09 9.0000000000e-01 6.7269140287e-09 9.6000000000e-01 6.7902034823e-09 1.0200000000e+00 \
 6.8830541949e-09 1.0800000000e+00 6.9270920553e-09 1.1040000000e+00 7.0057642142e-09 1.1280000000e+00 7.0850139971e-09 1.1520000000e+00 7.4666609244e-09 1.1760000000e+00 \
 1.0651217590e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  97 6.0200000000e-09 5.0000000000e-12 7.0000000000e-10 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199992347e-09 0.0000000000e+00 \
 6.0947788167e-09 2.4000000000e-02 6.1418332530e-09 4.8000000000e-02 6.1541385209e-09 7.2000000000e-02 6.1664659784e-09 9.6000000000e-02 6.1787996980e-09 1.2000000000e-01 \
 6.2102593665e-09 1.8000000000e-01 6.2421058126e-09 2.4000000000e-01 6.2747382279e-09 3.0000000000e-01 6.3078137450e-09 3.6000000000e-01 6.3428629840e-09 4.2000000000e-01 \
 6.3779122229e-09 4.8000000000e-01 6.4129614619e-09 5.4000000000e-01 6.4489724455e-09 6.0000000000e-01 6.4891617349e-09 6.6000000000e-01 6.5293510243e-09 7.2000000000e-01 \
 6.5695403137e-09 7.8000000000e-01 6.6183659593e-09 8.4000000000e-01 6.6726399940e-09 9.0000000000e-01 6.7269140287e-09 9.6000000000e-01 6.7902034823e-09 1.0200000000e+00 \
 6.8830541949e-09 1.0800000000e+00 6.9270920553e-09 1.1040000000e+00 7.0057642142e-09 1.1280000000e+00 7.0850139971e-09 1.1520000000e+00 7.4666609244e-09 1.1760000000e+00 \
 1.0651217590e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  98 6.0200000000e-09 5.0000000000e-12 7.0000000000e-10 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199992347e-09 0.0000000000e+00 \
 6.0947788167e-09 2.4000000000e-02 6.1418332530e-09 4.8000000000e-02 6.1541385209e-09 7.2000000000e-02 6.1664659784e-09 9.6000000000e-02 6.1787996980e-09 1.2000000000e-01 \
 6.2102593665e-09 1.8000000000e-01 6.2421058126e-09 2.4000000000e-01 6.2747382279e-09 3.0000000000e-01 6.3078137450e-09 3.6000000000e-01 6.3428629840e-09 4.2000000000e-01 \
 6.3779122229e-09 4.8000000000e-01 6.4129614619e-09 5.4000000000e-01 6.4489724455e-09 6.0000000000e-01 6.4891617349e-09 6.6000000000e-01 6.5293510243e-09 7.2000000000e-01 \
 6.5695403137e-09 7.8000000000e-01 6.6183659593e-09 8.4000000000e-01 6.6726399940e-09 9.0000000000e-01 6.7269140287e-09 9.6000000000e-01 6.7902034823e-09 1.0200000000e+00 \
 6.8830541949e-09 1.0800000000e+00 6.9270920553e-09 1.1040000000e+00 7.0057642142e-09 1.1280000000e+00 7.0850139971e-09 1.1520000000e+00 7.4666609244e-09 1.1760000000e+00 \
 1.0651217590e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
  99 6.0200000000e-09 5.0000000000e-12 7.0000000000e-10 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199992347e-09 0.0000000000e+00 \
 6.0947788167e-09 2.4000000000e-02 6.1418332530e-09 4.8000000000e-02 6.1541385209e-09 7.2000000000e-02 6.1664659784e-09 9.6000000000e-02 6.1787996980e-09 1.2000000000e-01 \
 6.2102593665e-09 1.8000000000e-01 6.2421058126e-09 2.4000000000e-01 6.2747382279e-09 3.0000000000e-01 6.3078137450e-09 3.6000000000e-01 6.3428629840e-09 4.2000000000e-01 \
 6.3779122229e-09 4.8000000000e-01 6.4129614619e-09 5.4000000000e-01 6.4489724455e-09 6.0000000000e-01 6.4891617349e-09 6.6000000000e-01 6.5293510243e-09 7.2000000000e-01 \
 6.5695403137e-09 7.8000000000e-01 6.6183659593e-09 8.4000000000e-01 6.6726399940e-09 9.0000000000e-01 6.7269140287e-09 9.6000000000e-01 6.7902034823e-09 1.0200000000e+00 \
 6.8830541949e-09 1.0800000000e+00 6.9270920553e-09 1.1040000000e+00 7.0057642142e-09 1.1280000000e+00 7.0850139971e-09 1.1520000000e+00 7.4666609244e-09 1.1760000000e+00 \
 1.0651217590e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
 100 6.0200000000e-09 5.0000000000e-12 7.0000000000e-10 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199992347e-09 0.0000000000e+00 \
 6.0947788167e-09 2.4000000000e-02 6.1418332530e-09 4.8000000000e-02 6.1541385209e-09 7.2000000000e-02 6.1664659784e-09 9.6000000000e-02 6.1787996980e-09 1.2000000000e-01 \
 6.2102593665e-09 1.8000000000e-01 6.2421058126e-09 2.4000000000e-01 6.2747382279e-09 3.0000000000e-01 6.3078137450e-09 3.6000000000e-01 6.3428629840e-09 4.2000000000e-01 \
 6.3779122229e-09 4.8000000000e-01 6.4129614619e-09 5.4000000000e-01 6.4489724455e-09 6.0000000000e-01 6.4891617349e-09 6.6000000000e-01 6.5293510243e-09 7.2000000000e-01 \
 6.5695403137e-09 7.8000000000e-01 6.6183659593e-09 8.4000000000e-01 6.6726399940e-09 9.0000000000e-01 6.7269140287e-09 9.6000000000e-01 6.7902034823e-09 1.0200000000e+00 \
 6.8830541949e-09 1.0800000000e+00 6.9270920553e-09 1.1040000000e+00 7.0057642142e-09 1.1280000000e+00 7.0850139971e-09 1.1520000000e+00 7.4666609244e-09 1.1760000000e+00 \
 1.0651217590e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
 101 6.0200000000e-09 5.0000000000e-12 7.0000000000e-10 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199992347e-09 0.0000000000e+00 \
 6.0947788167e-09 2.4000000000e-02 6.1418332530e-09 4.8000000000e-02 6.1541385209e-09 7.2000000000e-02 6.1664659784e-09 9.6000000000e-02 6.1787996980e-09 1.2000000000e-01 \
 6.2102593665e-09 1.8000000000e-01 6.2421058126e-09 2.4000000000e-01 6.2747382279e-09 3.0000000000e-01 6.3078137450e-09 3.6000000000e-01 6.3428629840e-09 4.2000000000e-01 \
 6.3779122229e-09 4.8000000000e-01 6.4129614619e-09 5.4000000000e-01 6.4489724455e-09 6.0000000000e-01 6.4891617349e-09 6.6000000000e-01 6.5293510243e-09 7.2000000000e-01 \
 6.5695403137e-09 7.8000000000e-01 6.6183659593e-09 8.4000000000e-01 6.6726399940e-09 9.0000000000e-01 6.7269140287e-09 9.6000000000e-01 6.7902034823e-09 1.0200000000e+00 \
 6.8830541949e-09 1.0800000000e+00 6.9270920553e-09 1.1040000000e+00 7.0057642142e-09 1.1280000000e+00 7.0850139971e-09 1.1520000000e+00 7.4666609244e-09 1.1760000000e+00 \
 1.0651217590e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
 102 6.0200000000e-09 5.0000000000e-12 7.0000000000e-10 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199992347e-09 0.0000000000e+00 \
 6.0947788167e-09 2.4000000000e-02 6.1418332530e-09 4.8000000000e-02 6.1541385209e-09 7.2000000000e-02 6.1664659784e-09 9.6000000000e-02 6.1787996980e-09 1.2000000000e-01 \
 6.2102593665e-09 1.8000000000e-01 6.2421058126e-09 2.4000000000e-01 6.2747382279e-09 3.0000000000e-01 6.3078137450e-09 3.6000000000e-01 6.3428629840e-09 4.2000000000e-01 \
 6.3779122229e-09 4.8000000000e-01 6.4129614619e-09 5.4000000000e-01 6.4489724455e-09 6.0000000000e-01 6.4891617349e-09 6.6000000000e-01 6.5293510243e-09 7.2000000000e-01 \
 6.5695403137e-09 7.8000000000e-01 6.6183659593e-09 8.4000000000e-01 6.6726399940e-09 9.0000000000e-01 6.7269140287e-09 9.6000000000e-01 6.7902034823e-09 1.0200000000e+00 \
 6.8830541949e-09 1.0800000000e+00 6.9270920553e-09 1.1040000000e+00 7.0057642142e-09 1.1280000000e+00 7.0850139971e-09 1.1520000000e+00 7.4666609244e-09 1.1760000000e+00 \
 1.0651217590e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
 103 6.0200000000e-09 5.0000000000e-12 7.0000000000e-10 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199992347e-09 0.0000000000e+00 \
 6.0947788167e-09 2.4000000000e-02 6.1418332530e-09 4.8000000000e-02 6.1541385209e-09 7.2000000000e-02 6.1664659784e-09 9.6000000000e-02 6.1787996980e-09 1.2000000000e-01 \
 6.2102593665e-09 1.8000000000e-01 6.2421058126e-09 2.4000000000e-01 6.2747382279e-09 3.0000000000e-01 6.3078137450e-09 3.6000000000e-01 6.3428629840e-09 4.2000000000e-01 \
 6.3779122229e-09 4.8000000000e-01 6.4129614619e-09 5.4000000000e-01 6.4489724455e-09 6.0000000000e-01 6.4891617349e-09 6.6000000000e-01 6.5293510243e-09 7.2000000000e-01 \
 6.5695403137e-09 7.8000000000e-01 6.6183659593e-09 8.4000000000e-01 6.6726399940e-09 9.0000000000e-01 6.7269140287e-09 9.6000000000e-01 6.7902034823e-09 1.0200000000e+00 \
 6.8830541949e-09 1.0800000000e+00 6.9270920553e-09 1.1040000000e+00 7.0057642142e-09 1.1280000000e+00 7.0850139971e-09 1.1520000000e+00 7.4666609244e-09 1.1760000000e+00 \
 1.0651217590e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
 104 6.0200000000e-09 5.0000000000e-12 9.0000000000e-10 3.8000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199991809e-09 0.0000000000e+00 \
 6.1000342849e-09 2.4000000000e-02 6.1488592444e-09 4.8000000000e-02 6.1646260786e-09 7.2000000000e-02 6.1804604938e-09 9.6000000000e-02 6.1963357365e-09 1.2000000000e-01 \
 6.2367009904e-09 1.8000000000e-01 6.2776370196e-09 2.4000000000e-01 6.3199945640e-09 3.0000000000e-01 6.3623521084e-09 3.6000000000e-01 6.4070934020e-09 4.2000000000e-01 \
 6.4532732034e-09 4.8000000000e-01 6.4994530048e-09 5.4000000000e-01 6.5456328062e-09 6.0000000000e-01 6.5927534196e-09 6.6000000000e-01 6.6466729755e-09 7.2000000000e-01 \
 6.7005925315e-09 7.8000000000e-01 6.7558379392e-09 8.4000000000e-01 6.8292435482e-09 9.0000000000e-01 6.9026491572e-09 9.6000000000e-01 6.9809050927e-09 1.0200000000e+00 \
 7.0998611827e-09 1.0800000000e+00 7.1625933521e-09 1.1040000000e+00 7.2514089983e-09 1.1280000000e+00 7.3463474121e-09 1.1520000000e+00 7.5827239925e-09 1.1760000000e+00 \
 1.0502480802e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
 105 6.0200000000e-09 5.0000000000e-12 9.0000000000e-10 4.1000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199991809e-09 0.0000000000e+00 \
 6.1000342849e-09 2.4000000000e-02 6.1488592444e-09 4.8000000000e-02 6.1646260786e-09 7.2000000000e-02 6.1804604938e-09 9.6000000000e-02 6.1963357365e-09 1.2000000000e-01 \
 6.2367009904e-09 1.8000000000e-01 6.2776370196e-09 2.4000000000e-01 6.3199945640e-09 3.0000000000e-01 6.3623521084e-09 3.6000000000e-01 6.4070934020e-09 4.2000000000e-01 \
 6.4532732034e-09 4.8000000000e-01 6.4994530048e-09 5.4000000000e-01 6.5456328062e-09 6.0000000000e-01 6.5927534196e-09 6.6000000000e-01 6.6466729755e-09 7.2000000000e-01 \
 6.7005925315e-09 7.8000000000e-01 6.7558379392e-09 8.4000000000e-01 6.8292435482e-09 9.0000000000e-01 6.9026491572e-09 9.6000000000e-01 6.9809050927e-09 1.0200000000e+00 \
 7.0998611827e-09 1.0800000000e+00 7.1625933521e-09 1.1040000000e+00 7.2514089983e-09 1.1280000000e+00 7.3463474121e-09 1.1520000000e+00 7.5827239925e-09 1.1760000000e+00 \
 1.0502480802e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
 106 6.0200000000e-09 5.0000000000e-12 9.0000000000e-10 4.4000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199991809e-09 0.0000000000e+00 \
 6.1000342849e-09 2.4000000000e-02 6.1488592444e-09 4.8000000000e-02 6.1646260786e-09 7.2000000000e-02 6.1804604938e-09 9.6000000000e-02 6.1963357365e-09 1.2000000000e-01 \
 6.2367009904e-09 1.8000000000e-01 6.2776370196e-09 2.4000000000e-01 6.3199945640e-09 3.0000000000e-01 6.3623521084e-09 3.6000000000e-01 6.4070934020e-09 4.2000000000e-01 \
 6.4532732034e-09 4.8000000000e-01 6.4994530048e-09 5.4000000000e-01 6.5456328062e-09 6.0000000000e-01 6.5927534196e-09 6.6000000000e-01 6.6466729755e-09 7.2000000000e-01 \
 6.7005925315e-09 7.8000000000e-01 6.7558379392e-09 8.4000000000e-01 6.8292435482e-09 9.0000000000e-01 6.9026491572e-09 9.6000000000e-01 6.9809050927e-09 1.0200000000e+00 \
 7.0998611827e-09 1.0800000000e+00 7.1625933521e-09 1.1040000000e+00 7.2514089983e-09 1.1280000000e+00 7.3463474121e-09 1.1520000000e+00 7.5827239925e-09 1.1760000000e+00 \
 1.0502480802e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
 107 6.0200000000e-09 5.0000000000e-12 9.0000000000e-10 4.7000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199991809e-09 0.0000000000e+00 \
 6.1000342849e-09 2.4000000000e-02 6.1488592444e-09 4.8000000000e-02 6.1646260786e-09 7.2000000000e-02 6.1804604938e-09 9.6000000000e-02 6.1963357365e-09 1.2000000000e-01 \
 6.2367009904e-09 1.8000000000e-01 6.2776370196e-09 2.4000000000e-01 6.3199945640e-09 3.0000000000e-01 6.3623521084e-09 3.6000000000e-01 6.4070934020e-09 4.2000000000e-01 \
 6.4532732034e-09 4.8000000000e-01 6.4994530048e-09 5.4000000000e-01 6.5456328062e-09 6.0000000000e-01 6.5927534196e-09 6.6000000000e-01 6.6466729755e-09 7.2000000000e-01 \
 6.7005925315e-09 7.8000000000e-01 6.7558379392e-09 8.4000000000e-01 6.8292435482e-09 9.0000000000e-01 6.9026491572e-09 9.6000000000e-01 6.9809050927e-09 1.0200000000e+00 \
 7.0998611827e-09 1.0800000000e+00 7.1625933521e-09 1.1040000000e+00 7.2514089983e-09 1.1280000000e+00 7.3463474121e-09 1.1520000000e+00 7.5827239925e-09 1.1760000000e+00 \
 1.0502480802e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
 108 6.0200000000e-09 5.0000000000e-12 9.0000000000e-10 5.0000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199991809e-09 0.0000000000e+00 \
 6.1000342849e-09 2.4000000000e-02 6.1488592444e-09 4.8000000000e-02 6.1646260786e-09 7.2000000000e-02 6.1804604938e-09 9.6000000000e-02 6.1963357365e-09 1.2000000000e-01 \
 6.2367009904e-09 1.8000000000e-01 6.2776370196e-09 2.4000000000e-01 6.3199945640e-09 3.0000000000e-01 6.3623521084e-09 3.6000000000e-01 6.4070934020e-09 4.2000000000e-01 \
 6.4532732034e-09 4.8000000000e-01 6.4994530048e-09 5.4000000000e-01 6.5456328062e-09 6.0000000000e-01 6.5927534196e-09 6.6000000000e-01 6.6466729755e-09 7.2000000000e-01 \
 6.7005925315e-09 7.8000000000e-01 6.7558379392e-09 8.4000000000e-01 6.8292435482e-09 9.0000000000e-01 6.9026491572e-09 9.6000000000e-01 6.9809050927e-09 1.0200000000e+00 \
 7.0998611827e-09 1.0800000000e+00 7.1625933521e-09 1.1040000000e+00 7.2514089983e-09 1.1280000000e+00 7.3463474121e-09 1.1520000000e+00 7.5827239925e-09 1.1760000000e+00 \
 1.0502480802e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
 109 6.0200000000e-09 5.0000000000e-12 9.0000000000e-10 5.3000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199991809e-09 0.0000000000e+00 \
 6.1000342849e-09 2.4000000000e-02 6.1488592444e-09 4.8000000000e-02 6.1646260786e-09 7.2000000000e-02 6.1804604938e-09 9.6000000000e-02 6.1963357365e-09 1.2000000000e-01 \
 6.2367009904e-09 1.8000000000e-01 6.2776370196e-09 2.4000000000e-01 6.3199945640e-09 3.0000000000e-01 6.3623521084e-09 3.6000000000e-01 6.4070934020e-09 4.2000000000e-01 \
 6.4532732034e-09 4.8000000000e-01 6.4994530048e-09 5.4000000000e-01 6.5456328062e-09 6.0000000000e-01 6.5927534196e-09 6.6000000000e-01 6.6466729755e-09 7.2000000000e-01 \
 6.7005925315e-09 7.8000000000e-01 6.7558379392e-09 8.4000000000e-01 6.8292435482e-09 9.0000000000e-01 6.9026491572e-09 9.6000000000e-01 6.9809050927e-09 1.0200000000e+00 \
 7.0998611827e-09 1.0800000000e+00 7.1625933521e-09 1.1040000000e+00 7.2514089983e-09 1.1280000000e+00 7.3463474121e-09 1.1520000000e+00 7.5827239925e-09 1.1760000000e+00 \
 1.0502480802e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
 110 6.0200000000e-09 5.0000000000e-12 9.0000000000e-10 5.6000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199991809e-09 0.0000000000e+00 \
 6.1000342849e-09 2.4000000000e-02 6.1488592444e-09 4.8000000000e-02 6.1646260786e-09 7.2000000000e-02 6.1804604938e-09 9.6000000000e-02 6.1963357365e-09 1.2000000000e-01 \
 6.2367009904e-09 1.8000000000e-01 6.2776370196e-09 2.4000000000e-01 6.3199945640e-09 3.0000000000e-01 6.3623521084e-09 3.6000000000e-01 6.4070934020e-09 4.2000000000e-01 \
 6.4532732034e-09 4.8000000000e-01 6.4994530048e-09 5.4000000000e-01 6.5456328062e-09 6.0000000000e-01 6.5927534196e-09 6.6000000000e-01 6.6466729755e-09 7.2000000000e-01 \
 6.7005925315e-09 7.8000000000e-01 6.7558379392e-09 8.4000000000e-01 6.8292435482e-09 9.0000000000e-01 6.9026491572e-09 9.6000000000e-01 6.9809050927e-09 1.0200000000e+00 \
 7.0998611827e-09 1.0800000000e+00 7.1625933521e-09 1.1040000000e+00 7.2514089983e-09 1.1280000000e+00 7.3463474121e-09 1.1520000000e+00 7.5827239925e-09 1.1760000000e+00 \
 1.0502480802e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
 111 6.0200000000e-09 5.0000000000e-12 9.0000000000e-10 5.9000000000e-15 \
 0.0000000000e+00 0.0000000000e+00 3.0000000000e-09 0.0000000000e+00 3.0100000000e-09 0.0000000000e+00 6.0100000000e-09 0.0000000000e+00 6.0199991809e-09 0.0000000000e+00 \
 6.1000342849e-09 2.4000000000e-02 6.1488592444e-09 4.8000000000e-02 6.1646260786e-09 7.2000000000e-02 6.1804604938e-09 9.6000000000e-02 6.1963357365e-09 1.2000000000e-01 \
 6.2367009904e-09 1.8000000000e-01 6.2776370196e-09 2.4000000000e-01 6.3199945640e-09 3.0000000000e-01 6.3623521084e-09 3.6000000000e-01 6.4070934020e-09 4.2000000000e-01 \
 6.4532732034e-09 4.8000000000e-01 6.4994530048e-09 5.4000000000e-01 6.5456328062e-09 6.0000000000e-01 6.5927534196e-09 6.6000000000e-01 6.6466729755e-09 7.2000000000e-01 \
 6.7005925315e-09 7.8000000000e-01 6.7558379392e-09 8.4000000000e-01 6.8292435482e-09 9.0000000000e-01 6.9026491572e-09 9.6000000000e-01 6.9809050927e-09 1.0200000000e+00 \
 7.0998611827e-09 1.0800000000e+00 7.1625933521e-09 1.1040000000e+00 7.2514089983e-09 1.1280000000e+00 7.3463474121e-09 1.1520000000e+00 7.5827239925e-09 1.1760000000e+00 \
 1.0502480802e-07 1.2000000000e+00 0.0000000000e+00 1.2000000000e+00 3.0000000000e-09 1.2000000000e+00 3.0100000000e-09 1.2000000000e+00 6.0100000000e-09 1.2000000000e+00 \
 6.0200000000e-09 1.2000000000e+00 9.0200000000e-09 1.2000000000e+00
}

* for Input Pin D1
Vn_D12 n_D12 gnd vsource type=pwl wave=[ \
 t_D10 v_D10 \
 t_D11 v_D11 \
 t_D12 v_D12 \
 t_D13 v_D13 \
 t_D14 v_D14 \
 t_D15 v_D15 \
 t_D16 v_D16 \
 t_D17 v_D17 \
 t_D18 v_D18 \
 t_D19 v_D19 \
 t_D110 v_D110 \
 t_D111 v_D111 \
 t_D112 v_D112 \
 t_D113 v_D113 \
 t_D114 v_D114 \
 t_D115 v_D115 \
 t_D116 v_D116 \
 t_D117 v_D117 \
 t_D118 v_D118 \
 t_D119 v_D119 \
 t_D120 v_D120 \
 t_D121 v_D121 \
 t_D122 v_D122 \
 t_D123 v_D123 \
 t_D124 v_D124 \
 t_D125 v_D125 \
 t_D126 v_D126 \
 t_D127 v_D127 \
 t_D128 v_D128 \
 t_D129 v_D129 \
 t_D130 v_D130 \
]
* for Input Pin SD
Vn_SD2 n_SD2 gnd vsource type=pwl wave=[ \
 t_SD0 v_SD0 \
 t_SD1 v_SD1 \
 t_SD2 v_SD2 \
 t_SD3 v_SD3 \
 t_SD4 v_SD4 \
 t_SD5 v_SD5 \
]

* .TRAN ==========================
timesweep sweep paramset=stimdata {
timedomain tran stop=3.9000000000e-08 autostop=yes
}
* InPin D1 PWL length=31 Sens=001
* InPin SD PWL length=6 Sens=111

* MEASUREMENT ==========================
simulator lang = spice

* Measurement starting time
.MEASURE TRAN nc_td PARAM = 'ncxtd'

* Load for Output pins
.MEASURE TRAN nc_sidecap PARAM = 'sidecap'
.MEASURE TRAN cap_Z PARAM = 'load_cap'

* Measure Input Reference Time
.MEASURE TRAN nc_inref_D1 WHEN V(n_D1) = 6.0000000000e-01 td = 'ncxtd' cross = 1
* input is rising

* Measure Gate Delay
.MEASURE TRAN nc_delay_D1_Z
* input is rising: vL=0.000000e+00, vH=1.200000e+00
+ trig V(n_D1) val = 6.0000000000e-01 td = 'ncxtd' cross = 1
* output is falling: vL=0.000000e+00, vH=1.200000e+00
+ targ V(n_Z) val = 6.0000000000e-01 td = 'ncxtd' cross = 1

* Measure Gate Output Transition Time
.MEASURE TRAN nc_optr_Z
+ trig V(n_Z) val = 1.0800000000e+00 td = 'ncxtd' cross = 1
+ targ V(n_Z) val = 1.2000000000e-01 td = 'ncxtd' cross = 1

* Measure Full Swing Output Transition Time (0.5% to 99.5%)
.MEASURE TRAN nc_fulloptr_Z
+ trig V(n_Z) val = 1.1940000000e+00 td = 'ncxtd' cross = 1
+ targ V(n_Z) val = 6.0000000000e-03 td = 'ncxtd' cross = 1

* Measure Input Trip Points
.MEASURE TRAN t_D1_trip1 WHEN V(n_D1) = 1.2000000000e-01 td = 'ncxtd' cross = 1
.MEASURE TRAN t_D1_trip2 WHEN V(n_D1) = 1.0800000000e+00 td = 'ncxtd' cross = 1

* Measure Input End Points(Rise)
.MEASURE TRAN t_stop_D1 WHEN V(n_D1) = 1.1400000000e+00 td = 'ncxtd' cross = 1

* Simulation Stop time with AutoSTOP
.MEASURE TRAN t_stop_Z WHEN V(n_Z) = 6.0000000000e-03 td = 'ncxtd' cross = 1
.MEASURE t_simstop PARAM = 'max(t_stop_Z, t_stop_D1)'

* Measure Input Capacitance
.MEASURE TRAN t_D1_trip_incap1 WHEN V(n_D1) = 6.0000000000e-03 td = 'ncxtd' cross = 1
.MEASURE TRAN t_D1_trip_incap2 WHEN V(n_D1) = 1.0800000000e+00 td = 'ncxtd' cross = 1
.MEASURE TRAN nc_intg_i_D1 INTEG I(Vn_D1) FROM = 't_D1_trip_incap1' TO = 't_D1_trip_incap2'
.MEASURE TRAN nc_intg_i1_D1 INTEG I(Vn_D1) FROM = 't_D1_trip_incap1' TO = 'nc_inref_D1'
.MEASURE TRAN nc_intg_i2_D1 INTEG I(Vn_D1) FROM = 'nc_inref_D1' TO = 't_D1_trip_incap2'
.MEASURE TRAN nc_incap_D1 param='ABS(nc_intg_i_D1/1.0740000000e+00)'
.MEASURE TRAN nc_incap_c1_D1 param='ABS(nc_intg_i1_D1/5.9400000000e-01)'
.MEASURE TRAN nc_incap_c2_D1 param='ABS(nc_intg_i2_D1/4.8000000000e-01)'

* Measure Input Transition Time
.MEASURE TRAN nc_iptr_D1 PARAM = 'iptr'
.MEASURE TRAN real_iptr_D1
+ trig V(n_D1) val = 1.2000000000e-01 td = 'ncxtd' cross = 1
+ targ V(n_D1) val = 1.0800000000e+00 td = 'ncxtd' cross = 1
.MEASURE TRAN nc_when_D1 param = '1'
.MEASURE TRAN nc_when_SD param = '1'
.MEASURE TRAN nc_when_Z param = '0'

* Measure Dynamic Energy
.MEASURE TRAN nc_dyn_energy INTEG par(' -(I(Vn_GND)*V(n_GND)) -(I(Vn_VDD)*V(n_VDD))') From= 'ncxtd' TO = 't_simstop'

* Energy Integral period
.MEASURE TRAN t_int_energy PARAM = 't_simstop - ncxtd'

* Measure Internal Energy
.MEASURE TRAN nc_int_energy PARAM = 'nc_dyn_energy'

* Measure Dynamic Energy in Power Supply
.MEASURE TRAN nc_dyn_eng_GND INTEG par(' -(I(Vn_GND)*V(n_GND))') From= 'ncxtd' TO = 't_simstop'
.MEASURE TRAN nc_dyn_eng_VDD INTEG par(' -(I(Vn_VDD)*V(n_VDD))') From= 'ncxtd' TO = 't_simstop'

* Measure Dynamic ABS Energy
.MEASURE TRAN nc_dyn_abs_energy INTEG par(' +ABS(I(Vn_GND)*V(n_GND)) +ABS(I(Vn_VDD)*V(n_VDD))') From= 'ncxtd' TO = 't_simstop'

* Measure total charge
.MEASURE TRAN nc_charge_GND INTEG I(Vn_GND) From= 'ncxtd' TO = 't_simstop'
.MEASURE TRAN nc_charge_VDD INTEG I(Vn_VDD) From= 'ncxtd' TO = 't_simstop'
 simulator lang = spectre
